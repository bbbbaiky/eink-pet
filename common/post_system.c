/* ══════════════════════════════════════════════════════════════════════
 * post_system.c —— 明信片系统（常规来信/笔友/我的收藏/照片明信片/未读位图）
 * ★2026-10-26 重构第 2 步：自 main.c 原位剪切（内容零改动，只摘 static）。
 * ══════════════════════════════════════════════════════════════════════ */
#include "variant.h"
#include <stdio.h>
#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdlib.h>
#include <time.h>
#include <sys/stat.h>
#include <dirent.h>
#include <ota_up.h>

#include <esp_log.h>
#include <esp_random.h>
#include <nvs.h>
#include <freertos/FreeRTOS.h>
#include <freertos/semphr.h>

#include "loot_data.h"
#include "loot_fx.h"
#include "main_api.h"
#include "assets.h"
#include "assets/loot_icons.h"
#include "i18n.h"
#include "post_data.h"
#include "api_image.h"
#include "friend.h"
#include "friend_net.h"
#include <esp_timer.h>
#include "post_ser_mask.h"      /* ★2026-10-26 修 bug③：每张片的「适用去向」bitmask（脚本生成） */

/* ★R150：原先这里有三行手写 extern（ws_upgrade_close / ws_post_open / ws_post_close）——
   本文件第 24 行已 include "main_api.h"，那里的原型才是真源，删掉避免两处漂移。 */
#include "loot_system.h"
#include "post_system.h"

/* TAG 由 main.c 定义、main_api.h extern（全工程同一 TAG） */

static bool mypost_before(int a, int b);
/* ★R189：落箱来源提示（0=手机相册 / 1=AI生成 / 2=朋友转寄）。
   mypost_add_body 在下方用到，定义放在这里 —— 语义说明见 mypost_src_hint()。 */
static uint8_t s_mp_src_hint = 0;
/* ★R119：mypost_add 会被 httpd 任务（网页导入）、MQTT 任务（好友寄片）、AI 任务
   三路并发调用。"挑空槽"是读-改-写，不加锁时两路可能挑中同一槽 → 一张卡被覆盖。
   assets_write/erase 自身有 SPI flash 锁，但槽位选择与 s_mp_ts 更新没有。 */
static SemaphoreHandle_t s_mp_mux = NULL;
static bool mypost_read(int e, uint8_t *dst);
static bool mypost_sd_read(int idx, uint32_t off, uint32_t len, uint8_t *dst);
static bool mypost_slot_get(int k, uint32_t *ts);
static bool mypost_store_sd(const uint8_t *photo,
                            uint32_t tl, const uint8_t *text,
                            uint32_t tal, const uint8_t *title,
                            uint32_t aal, const uint8_t *addr,
                            uint32_t sl, const uint8_t *sender);
static int mypost_read_addr (int k, char *dst, int cap);
static int mypost_read_field(int e, int want_addr, char *dst, int cap);
static int mypost_sd_open(int idx);
static int post_cat_of(int i);
static void mypost_unrd_load(void);
static void post_hold_btn_invert(void);
/* ★R150：post_arr_set / post_save 两行本地原型已删 —— post_system.h（本文件第 41 行 include）是真源。 */

/* ── 数据表本体（自数据头搬入）── */
const post_t g_posts[] = {
/* ══ 2026-10-25 二.2：近郊 27 张（插表头，photo 559..585；N_POST_BASE 271→298）══ */
    { "弄堂口","弄堂 上海黄浦 晴","03-15", "上海",
      "晾衣杆横在头顶 老人搬了竹椅坐 巷口谁也不说话 各自晒太阳", 559 },
    { "晾衣杆","弄堂 上海 晴","03-15", "上海",
      "衬衫床单挂成一片 风一起就鼓成帆 楼上探头收衣服 差点碰翻花盆", 560 },
    { "江边的钟楼","外滩 上海 夜","10-07", "上海",
      "钟敲了六下 江风把声音吹得很远 对岸的灯一层层亮 像在回答", 561 },
    { "屋顶的一角","胡同 北京西城 晴","10-23", "北京",
      "从四合院往外看 屋脊连着屋脊 鸽哨从头顶掠过 一圈就没影了", 562 },
    { "故宫的角楼","故宫 北京东城 黄昏","10-23", "北京",
      "角楼的影子倒进筒子河 护城河边有人拉二胡 我蹲着听完了整首", 563 },
    { "秦淮河","秦淮河 江苏南京 夜","11-15", "南京",
      "灯船一只接一只 桨声搅碎了满河的光 岸上卖桂花糕的 在喊最后几块", 564 },
    { "街边的梧桐","梧桐大道 南京 晴","11-15", "南京",
      "两排梧桐把天遮成一条缝 斑驳的光落在肩上 走到尽头回头 树影连成一片", 565 },
    { "海边的一棵树","环岛路 厦门 晴","04-20", "厦门",
      "沙滩上就这一棵树 影子被太阳压得很短 我在树下打了个盹 醒来潮涨了", 566 },
    { "雪中的屋脊","中央大街 哈尔滨 雪","12-20", "哈尔滨",
      "雪一层层盖在绿色的屋顶上 面包石的路面也白了 呼出的气结成霜 挂在睫毛上", 567 },
    { "洱海边的树","洱海 云南大理 晨","10-26", "大理",
      "一棵歪脖树站在水边 根扎得很深 苍山在它身后 天光刚翻出鱼肚白", 568 },
    { "一只茶碗","人民公园 成都 阴","10-09", "成都",
      "盖碗茶三块钱 续水不限次 我坐在竹椅上把一碗茶 喝到没有味道", 569 },
    { "一把竹椅","茶馆 四川成都 阴","10-09", "成都",
      "竹椅被坐得油亮 榫头都松了 坐下去嘎吱一声 老板说这把比你爷爷年纪大", 570 },
    { "白墙上的窗","八廓街 拉萨 晴","10-03", "拉萨",
      "白墙上开一扇黑框窗 窗台上摆了一盆干花 转角处桑烟升起 呛得眼泪出来", 571 },
    { "沙丘的曲线","鸣沙山 甘肃敦煌 黄昏","10-11", "敦煌",
      "沙丘的弧线被日落描成金 一阵风吹来 线条就换了一种弯法 脚印也跟着没了", 572 },
    { "一束花","斗南 昆明 晴","03-08", "昆明",
      "花市按斤称 玫瑰论把卖 老板娘塞了一把满天星说送你 我抱着花坐了很久的公交", 573 },
    { "山坡上的茶垄","龙井 浙江 杭州 晴","10-08", "杭州",
      "一排排茶树顺着山势弯 采茶人腰间挂篓 篓满了就倒进麻袋 动作没停过", 574 },
    { "湖上的一条船","西湖 浙江杭州 晨","10-08", "杭州",
      "一条摇橹船从雾里出来 船头堆着两筐藕 摇船的人哼着调 没人听懂也没人问", 575 },
    { "湖上的荷叶","曲院风荷 杭州 小雨","10-08", "杭州",
      "荷叶接住了整场雨 凹进去的部分积成一汪小水 风一倾倒 就全泼回了湖里", 576 },
    { "漓江的山","漓江 广西桂林 晴","10-16", "桂林",
      "山不高却很陡 一座隔着一座 竹筏从山脚滑过 水里的倒影比真的还清楚", 577 },
    { "园林的花窗","拙政园 江苏苏州 晴","10-13", "苏州",
      "花窗把院子框成一幅画 从这头看是一棵松 走到那头再看 变成了一丛竹", 578 },
    { "水巷","平江路 苏州 晴","10-13", "苏州",
      "河道窄得两只船要侧身过 墙根的青苔一路绿到水边 洗菜的水顺流漂走", 579 },
    { "城墙根","城墙 陕西西安 黄昏","10-10", "西安",
      "城墙根下有人下棋 围观的人比下棋的还急 夕阳把砖照得发烫 我靠着墙听完了一盘", 580 },
    { "塔尖上的天","大雁塔 西安 多云","10-10", "西安",
      "塔尖戳进云里 什么也看不见 塔下有人写字卖 一笔一划都是名字", 581 },
    { "海边的红屋顶","八大关 青岛 晴","06-12", "青岛",
      "红屋顶一排排铺到海边 石墙上的藤蔓开了花 浪声一阵接一阵 从来没停过", 582 },
    { "湖与天","青海湖 青海 多云","10-19", "青海湖",
      "湖和天之间只剩一条线 云的影子在湖面上跑 我追了一阵 追不上", 583 },
    { "半山的石阶","半山 中国香港 晴","10-14", "香港",
      "石阶一级接一级 两侧的老楼晾满了衣服 转角处有人搬铁凳坐着 看不完的报纸", 584 },
    { "天星小轮","维多利亚港 中国香港 夜","10-14", "香港",
      "小轮慢慢横过海 两岸的灯在水面上拉成长线 甲板的风很咸 吹得人不想靠岸", 585 },
/* ══ 2026-10-25 三.3：新批 432 张之「日常 224」（常规132+笔友92，插在 N_POST_BASE 之前）══ */
    { "吊脚楼一层层堆在崖上","洪崖洞 重庆 夜","01-02", "重庆",
      "吊脚楼一层层贴着崖壁 灯从山脚亮到山顶 江风从木板缝里钻过来 凉凉地拂过耳朵", 127 },
    { "一根细高的塔立在江边","广州塔 广东 晴","01-04", "广州",
      "塔立得笔直 帽尖插进云里 江面亮闪闪的 船慢慢驶过去 拖出一道水痕", 128 },
    { "楼一层层挑起檐角","黄鹤楼 湖北武汉 晴","01-06", "武汉",
      "楼檐翘得老高 一层一层往上叠 长江就在山脚下淌 汽笛声远远地传过来", 129 },
    { "一溜洋楼排在街上","五大道 天津 晴","01-08", "天津",
      "洋楼一栋挨一栋排开 铁栏杆花纹各不相同 树影落在墙上 一晃一晃", 130 },
    { "长堤一直伸到海里","栈桥 山东青岛 晴","01-10", "青岛",
      "长堤直直伸进海里 浪在脚边一下一下拍 回澜阁的顶透着光 远处的船冒着烟", 131 },
    { "红屋顶藏在棕榈下","鼓浪屿 福建厦门 晴","01-12", "厦门",
      "红屋顶藏在树后面 巷子绕着岛走 钢琴声从某扇窗飘出来 踩着石板一路找", 132 },
    { "大佛坐在石壁里","龙门石窟 河南 晴","01-14", "洛阳",
      "大佛坐在石壁里 表情很平静 风从伊河吹过来 带着水草的腥气", 133 },
    { "两座石塔并排站着","开元寺 福建泉州 晴","01-16", "泉州",
      "两座石塔并肩站着 塔身爬满岁月痕迹 桑叶落在阶前 扫帚慢慢地扫", 134 },
    { "土墙土顶围出一条巷子","老城 新疆喀什 晴","01-18", "喀什",
      "土墙围出一条窄巷 窗台摆满花盆 馕香从门缝飘出来 拐个弯又没了", 135 },
    { "两边吊脚楼夹着一条江","沱江 湖南凤凰 晨","01-20", "凤凰",
      "吊脚楼夹着江排开 晨雾还没散尽 棒槌声一声一声 敲在水面上", 136 },
    { "长廊沿着河一路过去","烟雨长廊 浙江西塘 小雨","01-22", "西塘",
      "长廊沿着河一路搭过去 雨点在瓦上跳 灯笼的影子在水里摇 我踩着干处走", 137 },
    { "石阶一直通到门底下","南天门 山东泰山 晴","01-24", "泰安",
      "石阶一直通到门底下 云在脚边流动 十八盘的拐弯处 歇脚的人搓着手", 138 },
    { "一根根石柱从雾里冒出来","天子山 湖南 雾","01-26", "张家界",
      "石柱一根根从雾里冒头 猴群在岩缝间跳 云雾漫上来 峰顶忽隐忽现", 139 },
    { "水浅得能看见沉在底下的木头","五花海 四川 晴","01-28", "九寨沟",
      "水浅得能看见沉在底下的木头 阳光一照 湖底泛出深深浅浅的蓝", 140 },
    { "河在林子中间拐了个弯","月亮湾 新疆 秋","01-30", "喀纳斯",
      "河在林子中间拐了个弯 水面漂满金色的落叶 对岸的白桦 黄得发亮", 141 },
    { "山顶上围着一圈水","天池 吉林 晴","02-01", "长白山",
      "山顶围着一圈水 静得像块蓝石头 风大得站不稳 毛全被吹向一边", 142 },
    { "石阶一级一级通到门下","中山陵 江苏南京 晴","02-03", "南京",
      "石阶一级一级通到门下 数也数不清 梧桐的影子盖在阶上 歇口气再接着爬", 143 },
    { "城墙一圈围着老城","古城墙 陕西西安 晴","02-05", "西安",
      "城墙围着老城转一大圈 砖缝里长着草 骑车的人慢慢经过 铃声响在午后", 144 },
    { "亭子盖在水池中间","拙政园 江苏苏州 晴","02-07", "苏州",
      "亭子盖在水池中间 曲桥连着岸 荷叶挤挤挨挨 锦鲤的影子在水底游", 145 },
    { "砖房一层层排到街尾","古城 山西平遥 晴","02-09", "平遥",
      "砖房一层层排到街尾 票号的门脸很气派 屋檐挂着红灯笼 风一吹就轻轻转头", 146 },
    { "宫墙顺着山坡叠上去","布达拉宫 西藏 晴","02-11", "拉萨",
      "宫墙顺着山坡叠上去 白墙金顶亮得晃眼 台阶高 我一级一级数着爬", 147 },
    { "木楼沿着水渠排开","古城 云南丽江 晴","02-13", "丽江",
      "木楼沿着水渠排开 流水从桥下过 垂柳叶子扫着水面 小鱼躲在阴凉里", 148 },
    { "石壁上凿出一排洞窟","莫高窟 甘肃 晴","02-15", "敦煌",
      "石壁上凿出一排洞窟 颜色还艳着 风从崖上刮过 带着细沙 眯着眼往里看", 149 },
    { "亭子立在湖边柳树下","避暑山庄 河北 晴","02-17", "承德",
      "亭子立在湖边柳树下 柳枝一直垂到水面 锦鲤游过 影子一颤一颤", 150 },
    { "大殿坐在高高的台基上","故宫 辽宁沈阳 晴","02-19", "沈阳",
      "大殿坐在高高的台基上 台阶陡 我绕到侧边 顺着缓坡慢慢上去", 151 },
    { "石牌坊后面没有屋顶","大三巴 中国澳门 晴","02-21", "澳门",
      "石牌坊后面没有屋顶 只剩一面墙立着 墙缝里长出小草 游人围着转圈", 152 },
    { "高楼一排贴着海边","维多利亚港 中国香港 晴","02-23", "香港",
      "高楼一排贴着海边 玻璃幕墙反着光 天星小轮慢慢驶过 汽笛响了一声", 153 },
    { "门楼一层层递进去","孔庙 山东曲阜 晴","02-25", "曲阜",
      "门楼一层层递进去 柏树长得老高 碑石上刻满字 我一个也不认识", 154 },
    { "桥上驮着五座亭子","五亭桥 江苏扬州 晴","02-27", "扬州",
      "桥上驮着五座亭子 桥洞一个个排开 瘦瘦的水面上 船娘摇着橹经过", 155 },
    { "三座白塔并排站在山前","崇圣寺三塔 云南大理 晴","03-01", "大理",
      "三座白塔并排站在山前 塔尖指着天 风吹过 檐角的铃铛轻轻响", 156 },
    { "土丘一座一座立在荒原上","西夏王陵 宁夏 晴","03-03", "银川",
      "土丘一座一座立在荒原上 形状像倒扣的碗 风穿过孔洞 呜呜地响", 157 },
    { "金顶小殿立在石崖上","金顶 湖北 晴","03-05", "武当山",
      "金顶小殿立在石崖上 铜瓦包着金 云在脚下翻涌 伸手好像能摸到", 158 },
    { "云海托着几座尖峰","云海 安徽 晴","03-07", "黄山",
      "云海托着几座尖峰 松树从石缝里横出来 日出那会儿 半边天都烧红了", 159 },
    { "小船滑过两排青山","漓江 广西 晴","03-09", "桂林",
      "小船滑过两排青山 竹竿一点 水面就皱一下 倒影跟着晃 山却不动", 160 },
    { "湖面宽得看不见对岸","洱海 云南 晴","03-11", "大理",
      "湖面宽得看不见对岸 云低低地压着 沿着湖走 风把耳朵吹得向后飞", 161 },
    { "湖边开着一长条花","湖畔 青海 晴","03-13", "青海湖",
      "湖边开着一长条花 黄灿灿的 一直开到天边 蜜蜂嗡嗡地忙着", 162 },
    { "马群散在草坡上","草原 内蒙古 晴","03-15", "呼伦贝尔",
      "马群散在草坡上 低头吃草 云影一片片移过去 牧民的摩托车突突响", 163 },
    { "胡杨光着枝干站成一片","胡杨林 内蒙古 秋","03-17", "额济纳",
      "胡杨光着枝干站成一片 叶子金黄金黄的 掉在地上厚厚一层 踩上去咯吱响", 164 },
    { "湖面平得像一面镜子","盐湖 青海 晴","03-19", "茶卡",
      "湖面平得像一面镜子 云掉在里面走 倒着走路 差点撞见另一个自己", 165 },
    { "梯田一层层绕上山","梯田 江西 春","03-21", "婺源",
      "梯田一层层绕上山 灌满了水 像碎镜子拼起来 耕田的人牵着牛慢慢走", 166 },
    { "河水从豁口翻下去","壶口瀑布 山西 晴","03-23", "吉县",
      "河水从豁口翻下去 水声震得耳朵嗡嗡的 水雾扑到脸上 凉得一个激灵", 167 },
    { "水帘一样挂下来","黄果树 贵州 晴","03-25", "安顺",
      "水帘一样从崖上挂下来 钻到帘后面去看 水珠砸在头上 透心凉", 168 },
    { "三座雪山围着一片湖","亚丁 四川 晴","03-27", "稻城",
      "三座雪山围着一片湖 雪顶亮得刺眼 经幡在风里扑啦啦地抖", 169 },
    { "山一层一层叠出彩带","丹霞 甘肃 晴","03-29", "张掖",
      "山一层一层叠出彩带 红黄相间 像谁把颜料泼上去 太阳一晒更艳", 170 },
    { "江水在峭壁中间拐弯","长江三峡 湖北 晴","03-31", "宜昌",
      "江水在峭壁中间拐弯 船贴着山根走 汽笛在峡谷里荡来荡去", 171 },
    { "楼檐压着一片大湖","岳阳楼 湖南 晴","04-02", "岳阳",
      "楼檐压着一片大湖 湖面烟波一眼望不到边 原来书里写的都是真的", 172 },
    { "江水从鱼嘴分成两股","鱼嘴 四川 晴","04-04", "都江堰",
      "江水从鱼嘴分成两股 一股急一股缓 两千多年了 还在老老实实地分江", 173 },
    { "双桥把河道拧成一个结","双桥 江苏昆山 晴","04-06", "周庄",
      "双桥把河道拧成一个结 桥洞圆方各一 摇橹船从桥下钻过 橹声咿呀", 174 },
    { "长廊沿河搭在水上","水上长廊 江苏吴江 晴","04-08", "同里",
      "长廊沿河搭在水上 廊檐遮住半条河 坐在栏杆上 脚就能碰着水", 175 },
    { "水阁一栋贴着一栋","水阁 浙江桐乡 晴","04-10", "乌镇",
      "水阁一栋贴着一栋 木桩子插在河里 推开窗就是水 船从窗下过", 176 },
    { "半月塘照出半个村子","宏村月沼 安徽 晴","04-12", "黟县",
      "半月塘照出半个村子 粉墙黛瓦倒在水里 大娘在塘边浣衣 棒槌声清脆", 177 },
    { "牌坊立在巷子口","胡文光牌坊 安徽 晴","04-14", "西递",
      "牌坊立在巷子口 石头上雕满故事 小狗从坊下钻过 尾巴摇得欢", 178 },
    { "城楼守着江湾","古城楼 四川 晴","04-16", "阆中",
      "城楼守着江湾 嘉陵江绕了个弯 楼上的风铃响 江面闪着碎光", 179 },
    { "水从镇中间穿过去","古镇 四川 晴","04-18", "黄龙溪",
      "水从镇中间穿过去 廊桥架在河上 孩子的凉鞋踩过青石板 水花四溅", 180 },
    { "溪水浅得能数石头","古村 浙江永嘉 晴","04-20", "楠溪江",
      "溪水浅得能数石头 石头青溜溜的 把爪子伸进去 凉得直缩", 181 },
    { "金顶一片叠在山坡上","松赞林寺 云南 晴","04-22", "香格里拉",
      "金顶一片叠在山坡上 红墙白墙错落着 转经筒沉甸甸的 推一把嗡嗡转", 182 },
    { "白塔围着金顶","塔尔寺 青海 晴","04-24", "西宁",
      "白塔围着金顶 塔身的白被岁月熏黄 酥油灯的味道飘过来 暖暖的", 183 },
    { "木楼挂在崖壁中间","悬空寺 山西 晴","04-26", "浑源",
      "木楼挂在崖壁中间 柱子细得让人担心 往上攀的时候 腿有点软", 184 },
    { "阁楼一层层压着江面","滕王阁 江西 晴","04-28", "南昌",
      "阁楼一层层压着江面 赣江的水泛着光 落霞飞过的时候 整层楼都是金的", 185 },
    { "亭子立在海角的石头上","蓬莱阁 山东 晴","04-30", "蓬莱",
      "亭子立在海角的石头上 崖下浪花翻白 运气好的话 能看见若隐若现的岛", 186 },
    { "城墙一头扎进海里","山海关 河北 晴","05-02", "秦皇岛",
      "城墙一头扎进海里 浪拍着城垛 六百年了 还守着这片海湾", 187 },
    { "土黄城楼守着戈壁滩","关城 甘肃 晴","05-04", "嘉峪关",
      "土黄城楼守着戈壁滩 城墙外是黄沙 风穿过瓮城 呜呜像有人喊", 188 },
    { "圆楼立在稻田中间","碉楼 广东 晴","05-06", "开平",
      "圆楼立在稻田中间 洋式的中式的混在一起 燕子绕着顶层飞 泥窝筑在梁上", 189 },
    { "小亭贴着水面","月到风来亭 江苏苏州 晴","05-08", "苏州",
      "小亭贴着水面 只一步就能跨进水里 风从四面来 竹帘哗啦一响", 190 },
    { "石头叠成一架小山","四季假山 江苏扬州 晴","05-10", "扬州",
      "石头叠成一架小山 洞里穿过厅旁 分不清哪季是哪季 索性都算春天", 191 },
    { "长廊一眼望不到头","颐和园长廊 北京 晴","05-12", "北京",
      "长廊一眼望不到头 梁上画满故事 走累了趴在栏杆上 昆明湖波光一片", 192 },
    { "石船停在昆明湖边","石舫 北京颐和园 晴","05-14", "北京",
      "石船停在昆明湖边 船身雕着花纹 永远开不走 倒也落个清净", 193 },
    { "墙上一排花窗","沧浪亭复廊 江苏苏州 晴","05-16", "苏州",
      "墙上一排花窗 每扇框住的景色都不同 透过漏窗看出去 竹子绿得发脆", 194 },
    { "泉水在石缝里响","八音涧 江苏无锡 晴","05-18", "无锡",
      "泉水在石缝里响 清清脆脆 藏在寄畅园深处 走近了才听得见", 195 },
    { "月亮门里藏着一座厅","余荫山房月门 广东 晴","05-20", "广州",
      "月亮门里藏着一座厅 门框圆圆的 迈过去像换了个世界 一下子安静", 196 },
    { "厅像一艘靠岸的船","清晖园船厅 广东 晴","05-22", "佛山",
      "厅像一艘靠岸的船 船头朝着池水 坐在厅里 像听见摇橹声", 197 },
    { "小阁探出树梢","可园邀山阁 广东 晴","05-24", "东莞",
      "小阁探出树梢 木梯窄窄的 爬上去推开窗 半个湖都在眼前", 198 },
    { "一扇窗框住一面湖","郭庄漏窗 浙江杭州 晴","05-26", "杭州",
      "一扇窗框住一面湖 窗格是朵花的形状 从洞里看出去 苏堤像条线", 199 },
    { "小轩立在池边","沈园孤鹤轩 浙江 晴","05-28", "绍兴",
      "小轩立在池边 荷花开得正好 宫墙上的字迹还在 故事却不是好结局", 200 },
    { "石头一步一步过池","艺圃浴鸥池 江苏苏州 晴","05-30", "苏州",
      "石头一步一步过池 水清得见底 园子小得转个身就到头 偏偏耐看", 201 },
    { "幡旗中间人挤人","地坛庙会 北京 晴","06-01", "北京",
      "幡旗中间人挤人 糖葫芦举得高高 锣鼓一响 人群就涌过去", 202 },
    { "摊主在灯下忙活","夜市摊 广东广州 晴","06-03", "广州",
      "摊主在灯下忙活 锅气一股一股往上冒 炒粉的香味勾着人 走不动路", 203 },
    { "茶客围着方桌坐","老茶馆 重庆 晴","06-05", "重庆",
      "茶客围着方桌坐 盖碗茶沏上 瓜子壳吐了一地 一下午就这么过去", 204 },
    { "挑夫从船上卸货","码头挑夫 湖北宜昌 晴","06-07", "宜昌",
      "挑夫从船上卸货 扁担颤颤悠悠 号子喊得低沉 脚步踩在跳板上咚咚响", 205 },
    { "台上唱台下看","水乡戏台 浙江绍兴 晴","06-09", "绍兴",
      "台上唱台下看 戏文听不懂 水袖一甩 满堂叫好 我也跟着叫", 206 },
    { "长龙在街里游","舞龙 广东佛山 晴","06-11", "佛山",
      "长龙在街里游 绣球一引 龙头就跟着走 鼓点密起来 龙身翻腾", 207 },
    { "老师傅吹出一只兽","吹糖人 天津 晴","06-13", "天津",
      "老师傅吹出一只兽 腮帮一鼓一鼓 糖丝在手里拉长 一会儿就硬了", 208 },
    { "影子映在亮布上","皮影戏 陕西西安 晴","06-15", "西安",
      "影子映在亮布上 小人儿挥刀舞枪 灯后面 老艺人的手翻飞", 209 },
    { "一圈人听得入神","树下说书 江苏扬州 晴","06-17", "扬州",
      "一圈人听得入神 扇子一敲 惊堂木啪的一下 说到紧要处 停了", 210 },
    { "菜担一排排摆开","早市菜摊 云南昆明 晴","06-19", "昆明",
      "菜担一排排摆开 带着露水的青菜 菌子刚从山里来 喇叭喊得响", 211 },
    { "桨手一齐划","赛龙舟 湖南汨罗 晴","06-21", "汨罗",
      "桨手一齐划 鼓声擂得急 船头像箭一样 水花溅了满头", 212 },
    { "高跷走过长街","踩高跷 河北沧州 晴","06-23", "沧州",
      "高跷走过长街 一步比一步高 小孩仰着头看 手里的风车转着", 213 },
    { "火星子溅在砧上","打铁铺 山东淄博 晴","06-25", "淄博",
      "火星子溅在砧上 一锤下去一声脆 师傅的胳膊 比铁还硬", 214 },
    { "镜子挂在担子上","街角剃头 上海 晴","06-27", "上海",
      "镜子挂在担子上 老师傅的手艺稳 推子嗡嗡过 头发落了一地", 215 },
    { "花枝探过村巷来","鼋头渚樱花 江苏 春","06-29", "无锡",
      "花枝探过村巷来 粉云一样 风一过 花瓣落得满头满身", 216 },
    { "荷叶宽得像伞","曲院风荷 浙江 夏","07-01", "杭州",
      "荷叶宽得像伞 挤挤挨挨连到天边 露珠在叶心滚 滑下去碎八瓣", 217 },
    { "枫叶红时路也红","天平山枫叶 江苏 秋","07-03", "苏州",
      "枫叶红时路也红 石阶像铺了毯 踩上去软绵绵 抬头全是火苗", 218 },
    { "雪把屋顶盖厚了","雪后徽村 安徽 冬","07-05", "徽州",
      "雪把屋顶盖厚了 马头墙戴着白帽 烟囱里升起烟 慢悠悠的", 219 },
    { "竹子密得遮天","蜀南竹海 四川 晴","07-07", "宜宾",
      "竹子密得遮天 阳光切成细条 风一过 整片林子哗哗响", 220 },
    { "茶垄一圈圈绕山","龙井茶园 浙江 春","07-09", "龙井",
      "茶垄一圈圈绕山 嫩芽一茬一茬采 指尖留香 像把春天捏在手里", 221 },
    { "黄花一直开到墙根","千垛菜花 江苏 春","07-11", "兴化",
      "黄花一直开到墙根 垛田像浮在水上的岛 摇橹进花海 头也看不见", 222 },
    { "苇穗压弯了腰","白洋淀芦苇 河北 秋","07-13", "保定",
      "苇穗压弯了腰 白茫茫一片 船钻进苇荡 水路曲曲弯弯", 223 },
    { "松树从石缝里横出来","凤凰松 安徽 晴","07-15", "九华山",
      "松树从石缝里横出来 枝干像展翅 一千三百年 还这么精神", 224 },
    { "花串一串串垂下来","紫藤架 上海 春","07-17", "嘉定",
      "花串一串串垂下来 紫得发亮 架子底下摆着石凳 坐一下午不腻", 225 },
    { "稻穗沉得抬不起头","稻浪 浙江 秋","07-19", "桐乡",
      "稻穗沉得抬不起头 风一推 金浪一层层滚 蟋蟀叫得正欢", 226 },
    { "果串藏在叶里","葡萄沟 新疆 夏","07-21", "吐鲁番",
      "果串藏在叶里 累累地挂着 摘一颗 甜到眯眼睛", 227 },
    { "叶子把地铺满了","古银杏 浙江 秋","07-23", "长兴",
      "叶子把地铺满了 厚厚一层 树干要几人合抱 金黄得耀眼", 228 },
    { "黄花挂满墙头","迎春花墙 江苏 春","07-25", "扬州",
      "黄花挂满墙头 枝条垂下半墙 蜜蜂忙着 整面墙都在轻轻颤", 229 },
    { "船小得像瓜子壳","东海 舟山群岛 晴","11-10", "小鸟邮局",
      "今早飞过东海 渔船缩成了瓜子壳 浪一排排推着它们 我差点叼走一面旗", 230 },
    { "烟囱比树还多","泉州古城 福建 晴","11-12", "小鸟邮局",
      "红砖楼顶挤满烟囱 一只鹌鹑在里面做窝 我数了三十根 数忘了", 231 },
    { "河在白纸上写字","黑龙江畔 哈尔滨 冬","11-14", "小鸟邮局",
      "大河在雪地上写字 一笔写到天边 我沿着墨迹飞 脚印是它盖的章", 232 },
    { "一串蚂蚁在走","鸣沙山 甘肃敦煌 晴","11-16", "小鸟邮局",
      "从云上看 驼队成了一串蚂蚁 沙子被风推着 一排排翻过去", 233 },
    { "我比旗云飞得高","牛背山 四川 多云","11-18", "小鸟邮局",
      "今早冲上云海 旗云在脚下飘 我比它还高一点 喘了口气", 234 },
    { "湖把它捧在手心","千岛湖 浙江 晴","11-20", "小鸟邮局",
      "湖水把岛捧在手心 一个个绿拇指 我数到五十 翅膀酸了", 235 },
    { "桥是一根细线","跨海大桥 山东青岛 晴","11-22", "小鸟邮局",
      "大桥细得像一根线 两头拴着两座城 车在线上爬 我俯冲下去 差点撞上", 236 },
    { "山睁着一只眼睛","五大连池 黑龙江 晴","11-24", "小鸟邮局",
      "火山口睁着一只眼睛 盛着一汪水 我在眼睫毛上歇脚 一圈一圈 把它看晕", 237 },
    { "喇叭朝着太阳吹","竹篱笆 江西婺源 夏","11-26", "蝴蝶邮局",
      "牵牛花朝着太阳吹喇叭 我钻进喇叭口 花粉扑了一身", 238 },
    { "一朵花就是一张床","呼伦贝尔 内蒙 夏","11-28", "蝴蝶邮局",
      "一朵花足以当床 我抱着花蕊睡了一午 醒来 满身都是香的", 239 },
    { "他站着睡着了","麦田 河南开封 夏","11-30", "蝴蝶邮局",
      "稻草人站着睡着了 帽子滑下来 我停在他的袖子上 替他放了一下午的哨", 240 },
    { "窗台上开满花","老街窗台 江苏苏州 晴","12-02", "蝴蝶邮局",
      "窗台摆满了花盆 我一层层拜访 从这家的粉 飞到那家的黄", 241 },
    { "墙也开花了","老城墙 山东曲阜 春","12-06", "蝴蝶邮局",
      "古城墙上也开了花 苔藓绿的 瓦松红的 我在砖缝里 找到一汪露水", 242 },
    { "它们都朝着太阳","伊犁 新疆 夏","12-08", "蝴蝶邮局",
      "向日葵一齐朝着太阳 我数了数 一百张笑脸 风一来 一齐点头", 243 },
    { "对岸长出一排楼","陆家嘴 上海 晴","12-10", "上海",
      "对岸的楼越冒越高 江风迎面吹 把鼻头吹得发凉 货轮的汽笛应了一声", 244 },
    { "路在空中打了结","黄桷湾 重庆 晴","12-11", "重庆",
      "路在空中打了结 七八层叠着转 我看着先晕了 司机们倒不慌不忙", 245 },
    { "列车钻出地面","李子坝 重庆 晴","12-12", "重庆",
      "列车钻出地面 从居民楼中间穿过 楼里住家 楼下列车 各不打扰", 246 },
    { "一条白色的长龙","南京南站 晴","12-13", "南京",
      "白色的长龙卧在站台 车头圆润 门一开 冷气混着消毒水味涌出来", 247 },
    { "吊机在搭积木","洋山港 晴","12-15", "上海",
      "吊机在搭积木 箱子一层层码上天 海面的货轮列着队 等着装卸", 248 },
    { "一口巨大的碗","鸟巢 北京 晴","12-16", "北京",
      "一口巨大的碗扣在场地上 钢条编成网 傍晚灯一亮 整座城都看着它", 249 },
    { "慢慢转的圆","天津之眼 晴","12-17", "天津",
      "慢慢转的圆 转到最高处 半城都在脚底下 风把耳朵吹得向后飞", 250 },
    { "新旧站在一起","外滩 上海 晴","12-18", "上海",
      "新旧站在一起 老钟楼对着新摩天楼 一个讲故事 一个打算盘", 251 },
    { "叮叮当当穿街过","大连 晴","12-19", "大连",
      "叮叮当当穿街过 木座椅旧得发亮 叮当一声 像从老电影里开出来", 252 },
    { "桥上都是赶路的人","广州 晴","12-20", "广州",
      "桥上都是赶路的人 脚步匆匆 我趴在栏杆上看 看了半个钟头", 253 },
    { "单车排好了队","深圳 晴","12-21", "深圳",
      "单车排好了队 黄的蓝的挨着 早高峰一放 队伍就散了", 254 },
    { "屋顶上的邻居","老城屋顶 厦门 晴","12-22", "厦门",
      "屋顶上的邻居 咕咕叫着起落 有人撒一把米 它们就扑棱棱围过去", 255 },
    { "楼下也有山","城市公园 北京 晴","12-23", "北京",
      "楼下也有山 不过是堆出来的 老人们打着太极 我躲在假山洞里图清静", 256 },
    { "逛街的人真多","春熙路 成都 晴","12-24", "成都",
      "逛街的人真多 橱窗一个接一个 我钻进行道树的影子里 顺流而下", 257 },
    { "深夜也亮着的窗","街角 上海 晴","12-25", "上海",
      "深夜也亮着的窗 关东煮咕嘟咕嘟 值夜班的人趴在桌上 我蹲在门口取暖", 258 },
    { "街角的香气","衡山路 上海 晴","12-26", "上海",
      "街角的香气 烘豆子的味道飘出来 门一推开 铃铛响 暖意扑脸", 259 },
    { "雨刚停","南京 雨后","12-27", "南京",
      "雨刚停 站台还湿着 蜗牛爬上广告牌 车灯隔着水雾照过来", 260 },
    { "城市在长高","深圳 晴","12-28", "深圳",
      "城市在长高 塔吊转着长臂 今天又砌高一层 地基里还埋着我的影子", 261 },
    { "两支铅笔插在楼里","CBD 北京 晴","12-29", "北京",
      "两支铅笔插在楼里 玻璃幕墙照着云 午休的人躺在花台上 我跟着眯一会儿", 262 },
    { "盘旋上去的路","重庆 晴","12-30", "重庆",
      "盘旋上去的路 一圈一圈绕到顶 下坡时最爽 风在耳边呼呼的", 263 },
    { "卖报纸的小亭子","街头 上海 晴","12-31", "上海",
      "卖报纸的小亭子 杂志码得整整齐齐 老板躺着听收音机 我帮忙看着摊", 264 },
    { "屋顶晒着太阳","深圳 晴","01-02", "深圳",
      "屋顶晒着太阳 蓝板子一片一片 晒过的板子暖暖的 蚂蚁顺着板沿排队", 265 },
    { "楼顶上的菜园","上海 晴","01-04", "上海",
      "楼顶上的菜园 番茄挂着青果 泡沫箱排成行 主人提水上来的脚步声最动听", 266 },
    { "傍晚的江风","武昌江滩 黄昏","01-06", "武汉",
      "傍晚的江风 步灯一盏盏亮了 钓鱼人的浮子一动不动 我陪坐到天黑", 267 },
    { "铁鸟落在广场上","青岛 晴","01-08", "青岛",
      "铁鸟落在广场上 翅膀张着 孩子把它当马骑 影子铺了半块地砖", 268 },
    { "上上下下的电梯","皇冠大扶梯 重庆 晴","01-10", "重庆",
      "上上下下的电梯 站在上面不用走 到顶回头一望 刚才还在楼底下", 269 },
    { "黄出租车等客人","北京 晴","01-12", "北京",
      "黄出租车停在路边 车顶灯亮着 司机摇下车窗抽烟 我蹲在花坛沿上看来往", 270 },
    { "绿色的老邮筒","成都 晴","01-14", "成都",
      "绿色的老邮筒 还守在街角 单车靠在一旁 现在的信 都从手机里走了", 271 },
    { "从这里看全城","观景台 上海 晴","01-16", "上海",
      "从这里看全城 楼像积木 路像绳子 夜里灯一亮 满地星星", 272 },
    { "江水细成一根线","长江三峡 湖北 高空","01-18", "小鸟邮局",
      "江在高山里拧成一根线 船是线上的扣 我顺着线飞 风从峡谷里顶上来", 273 },
    { "墙爬过一道道山","八达岭 北京 高空","01-20", "小鸟邮局",
      "城墙翻过一道道山 像一条晒太阳的蛇 我在敌楼里躲风 垛口外 云在跑", 274 },
    { "白蘑菇撒了一地","呼伦贝尔 内蒙 高空","01-22", "小鸟邮局",
      "草原上撒满白蘑菇 是羊群 我低飞掠过 它们一齐抬头 像约好了", 275 },
    { "潮水画的树杈","条子泥 江苏盐城 高空","01-24", "小鸟邮局",
      "潮水退成一树杈一树杈 滩涂上写满篆书 我踩着这些字 找螺吃", 276 },
    { "石头浮在浪上","舟山群岛 浙江 高空","01-26", "小鸟邮局",
      "礁石浮在浪上 像一排馒头 我落在最高的那个 咸风把羽毛吹成旗", 277 },
    { "大地的棋盘","盐田 海南乐东 高空","01-28", "小鸟邮局",
      "盐田方方正正 棋盘一样铺开 每格颜色都不一样 我落在那格蓝的边上", 278 },
    { "一地碎镜子","高原湖群 西藏 高空","01-30", "小鸟邮局",
      "高原的湖碎成一片片镜子 我一片片照过去 每片里 都有一只不一样的我", 279 },
    { "大风车站在海里","海上风场 江苏南通 高空","02-01", "小鸟邮局",
      "风车站在海里 叶子转得比我还慢 我钻进叶影 凉快了一秒", 280 },
    { "一朵花一座亭","花房 广东广州 春","02-03", "蝴蝶邮局",
      "一盆花就是一座小亭 我钻进去 梁是蕊 柱是瓣 住着不想走", 281 },
    { "花开在光枝上","街头玉兰 上海 早春","02-05", "蝴蝶邮局",
      "玉兰花开在光秃秃的枝上 一朵朵朝着天 我落在花瓣上 打了个滑", 282 },
    { "一垄一垄的香","薰衣草田 新疆伊犁 夏","02-07", "蝴蝶邮局",
      "薰衣草一垄一垄 香得能淹死人 我钻进垄沟 紫色的浪 一波一波", 283 },
    { "小伞一顶一顶","松林下 吉林长白 夏","02-09", "蝴蝶邮局",
      "松林下的小蘑菇一顶一顶 我认得出哪种有毒 哪种边上 蚂蚁在排队", 284 },
    { "花瓣去旅行","溪畔 浙江杭州 春","02-11", "蝴蝶邮局",
      "花瓣落进溪里 去旅行了 我跟着飞了一段 把它送过一块石头", 285 },
    { "叶子都是心形","草地 上海 春","02-13", "蝴蝶邮局",
      "草地上的叶子一颗一颗都是心 我落到最大的那颗上 它托着我 晃了晃", 286 },
    { "星星爬满架子","花架 江苏南京 春","02-15", "蝴蝶邮局",
      "花架上爬满星星 一朵朵小花 夜来才睁开眼 我趁着黄昏 先尝一口蜜", 287 },
    { "满坡小太阳","山坡 湖北神农架 秋","02-17", "蝴蝶邮局",
      "满坡的小太阳 是野菊 我落在最亮那朵上 影子投在另一朵上", 288 },
    { "沙洲是鸟的驿站","长江口 上海 高空","02-19", "小鸟邮局",
      "沙洲是我们的驿站 落一脚 喝一口 明天还要赶路 欢迎你也来住", 289 },
    { "坡上挖出的家","黄土高原 陕西 高空","02-21", "小鸟邮局",
      "窑洞挖在坡里 门帘一掀 飘出炊烟 我在坡顶盘旋 找到了自家的窗", 290 },
    { "我也在队伍里","南迁途中 华北 高空","02-23", "小鸟邮局",
      "南迁的队伍排成人字 我排在最后一个 领头的一路回头 怕我跟丢", 291 },
    { "湖面结了冰纹","冰湖 黑龙江 冬","02-25", "小鸟邮局",
      "湖面结满冰纹 一脚踩上去 裂纹追着我的影子跑 我赶紧跳开", 292 },
    { "水被山抱住了","水库 四川 高空","02-27", "小鸟邮局",
      "山把水抱在怀里 一抱就是千年 我从山口飞过 听见水底 有鱼在吹泡", 293 },
    { "田是一块块补丁","平原田块 河南 高空","03-01", "小鸟邮局",
      "平原的田像一块块补丁 绿的一块 黄的一块 我落在电线杆上 看农人缝补", 294 },
    { "路绕了十八弯","盘山公路 湖南 高空","03-03", "小鸟邮局",
      "公路绕着山盘了一圈又一圈 我直线飞过去 比开车快多了", 295 },
    { "船都回家了","渔港 山东 高空","03-05", "小鸟邮局",
      "傍晚 渔船一艘艘回家了 桅杆靠在一起 像一群累了的鹤 我落在桅杆上", 296 },
    { "喇叭口朝下开","菜园 山东寿光 夏","03-07", "蝴蝶邮局",
      "丝瓜的花口朝下开 我挂在花口上 晃荡 露水珠滴进嘴里", 297 },
    { "一路都有花陪","田埂 贵州 夏","03-09", "蝴蝶邮局",
      "田埂边一路有花作陪 我飞一段 停一段 蝴蝶的日程 不排满", 298 },
    { "叶子打着卷出生","林下 云南普洱 春","03-11", "蝴蝶邮局",
      "新叶子打着卷来到世上 像一支支小号 我等它展开 等了三天", 299 },
    { "豆花爬上竹竿","竹架 浙江绍兴 秋","03-13", "蝴蝶邮局",
      "豆蔓爬上竹竿 紫的一块 白的一块 我停在最高的节上 和蜜蜂打招呼", 300 },
    { "毛茸茸的穗子","路边 江苏 秋","03-15", "蝴蝶邮局",
      "狗尾草的穗子毛茸茸 我落上去 像坐了一把刷子 风来 一起一伏", 301 },
    { "石缝里开花","石缝 山东青岛 春","03-17", "蝴蝶邮局",
      "石缝里开出一朵小蓝花 根扎得比谁都深 我给它 讲了讲外面的海", 302 },
    { "朝开暮落也开","篱边 四川成都 夏","03-19", "蝴蝶邮局",
      "朝开暮落 它也照样开 知道自己短 开得比谁都认真 我陪它到合上花瓣", 303 },
    { "街道画成格子","市中心 上海 高空","03-21", "小鸟邮局",
      "街道画成一个个格子 人群是移动的棋子 我占领了钟楼的尖", 304 },
    { "瓦片像鱼鳞","老城 苏州 高空","03-23", "小鸟邮局",
      "老城的瓦一片压一片 像鱼鳞 我从屋脊这头 走到那头 没惊醒一只猫", 305 },
    { "车像芝麻在转","立交桥 广州 高空","03-25", "小鸟邮局",
      "立交桥盘成一层层 车流像芝麻在转 我挑最粗的那根梁 歇脚", 306 },
    { "轮渡拖着白线","江畔 武汉 高空","03-27", "小鸟邮局",
      "轮渡拖着一条白线过江 江鸥跟在尾巴后面 捡浪里翻上来的小鱼", 307 },
    { "操场是一个圆","大学城 南京 高空","03-29", "小鸟邮局",
      "操场圆得像个句号 跑道上一圈圈的红 我落在球门上 看他们跑圈", 308 },
    { "铁轨排成琴弦","火车站 北京 高空","03-31", "小鸟邮局",
      "铁轨排成一把琴弦 一列火车弹过去 嗡的一声 全城的琴都响了", 309 },
    { "桥上爬着小甲虫","跨江大桥 重庆 高空","04-02", "小鸟邮局",
      "大桥的斜拉索像琴弦 车在弦上爬 小得像甲虫 我逆着风 和他们对着走", 310 },
    { "楼群围着一面镜","城市公园 杭州 高空","04-04", "小鸟邮局",
      "楼群围着一面圆镜 是湖 我在楼顶和湖面之间 画了一道斜线", 311 },
    { "一桶一桶的春天","花店 上海 春","04-06", "蝴蝶邮局",
      "花店把春天装进一只只桶 郁金香站在桶里 我闻了一圈 选了最香的那桶", 312 },
    { "花种成一片毯","公园花圃 北京 春","04-08", "蝴蝶邮局",
      "公园把花种成一大块毯 红毯 黄毯 我降落在毯子中央 陷下去半寸", 313 },
    { "栏杆也开花了","铁栏杆 苏州 春","04-10", "蝴蝶邮局",
      "铁栏杆上缠满藤蔓 开着喇叭花 我站在栏杆上 和花 一般高", 314 },
    { "石缝里也有春天","老石阶 镇远 春","04-12", "蝴蝶邮局",
      "老石阶的缝里挤出几朵蓝花 根在石头里找路 我落在台阶上 看它们晒了一下午的太阳", 315 },
    { "花箱沿着栏杆","咖啡馆露台 上海 春","04-14", "蝴蝶邮局",
      "露台的花箱挨着栏杆排过去 天竺葵开得正闹 我落在杯沿上 客人搅咖啡的手 停住了", 316 },
    { "花落在一页书上","校园小路 南京 春","04-16", "蝴蝶邮局",
      "樱花落在一页摊开的书上 同学没舍得吹 我落在花瓣边 和他一起 读了两行", 317 },
    { "树下开了一条带","梧桐树下 上海 春","04-18", "蝴蝶邮局",
      "梧桐树下开了一条流浪花的带 蒲公英居多 我顺着带子飞 一路送它们出发", 318 },
    { "单车靠着花","小区楼下 成都 春","04-20", "蝴蝶邮局",
      "单车靠在花栏边 车筐里落了两片瓣 我停在车把上 等骑车的人下来", 319 },
    { "大河冻成了舌头","冰川峡湾 挪威 高空","04-22", "小鸟邮局",
      "冰川伸出一条蓝舌头 舔着海面 我落在舌头上 冰凉的 打了个颤", 320 },
    { "一条线通到天边","戈壁公路 甘肃 高空","04-24", "小鸟邮局",
      "公路一条直线甩到天边 一辆车走了半天 还是一个小点 风把电线吹得呜呜响", 321 },
    { "海上田字格","海上渔排 福建宁德 高空","04-26", "小鸟邮局",
      "渔排扎成海上一格一格 每格养着一种鱼 我停在木桩上 看人撒网", 322 },
    { "伙伴们都在下面","湿地 鄱阳湖 高空","04-28", "小鸟邮局",
      "冬天的湖全是伙伴 白的灰的一大片 我落进去 湖面黑了一块 又腾起来", 323 },
    { "大山在照镜子","哈尼梯田 云南 高空","04-30", "小鸟邮局",
      "群山对着梯田照镜子 一层一面小镜 我数了十三层 数到云里", 324 },
    { "风刻出一片船队","雅丹 甘肃 高空","05-02", "小鸟邮局",
      "风把土墩刻成一支船队 在沙海里航行 我落在最高的桅杆上 沙打过来 生疼", 325 },
    { "火车在云里过桥","铁路桥 贵州 高空","05-04", "小鸟邮局",
      "火车钻进云里 又从桥那头出来 我追着它飞 钻进云 浑身湿透", 326 },
    { "一条白线穿田去","高铁线 河南 高空","05-06", "小鸟邮局",
      "高铁把田切成两半 一道白线穿过去 我贴着车顶飞 它没发现我", 327 },
    { "花开得像个团子","牡丹 河南洛阳 谷雨","05-08", "蝴蝶邮局",
      "牡丹开得像个饱胀的团子 一层层花瓣裹着 我挤进花芯 转了个身 才找得到蕊", 328 },
    { "一朵花一个球","绣球 江苏南京 初夏","05-10", "蝴蝶邮局",
      "绣球一球一球地开 蓝的粉的 我落在球上 球比翅膀还大", 329 },
    { "香是看不见的","茉莉 福州 夏夜","05-12", "蝴蝶邮局",
      "茉莉小得不起眼 香却藏不住 看不见的那股 在夜里 跑得比风还远", 330 },
    { "雨里最香","栀子 上海 梅雨","05-14", "蝴蝶邮局",
      "栀子就挑雨天开 雨一淋 香往人鼻子里钻 我躲在叶下 浑身沾满甜的", 331 },
    { "冬天开得最稳","山茶 云南昆明 冬","05-16", "蝴蝶邮局",
      "山茶冬天也开 一树的花压在雪上 我落在最厚那朵上 它没弯", 332 },
    { "一排小酒杯","郁金香 北京 春","05-18", "蝴蝶邮局",
      "郁金香举起一只只小酒杯 等着谁来干杯 我挨个闻 每杯里的春天 度数不同", 333 },
    { "和牡丹是姐妹","芍药 山东菏泽 初夏","05-20", "蝴蝶邮局",
      "芍药是牡丹的妹妹 开得晚 也素净 我飞过牡丹丛 在她身边多停了一会儿", 334 },
    { "满城都是甜的","桂花 杭州 中秋","05-22", "蝴蝶邮局",
      "桂花一开 空气是蜜做的 满城都泡在甜里 我趴在窗台上 醉得不想动", 335 },
    { "河水直接跳进海","海岸瀑布 挪威 高空","05-24", "小鸟邮局",
      "大河不绕了 直接从崖上跳进海 我悬在瀑布边 水汽把翅膀打湿", 336 },
    { "海上一只花环","环礁 南海 高空","05-26", "小鸟邮局",
      "环礁是海上的花环 一圈绿 围着中间一块蓝 我从环上飞过 像在花蕊上散步", 337 },
    { "大地的纽扣","休眠火山群 内蒙古 高空","05-28", "小鸟邮局",
      "火山群像一枚枚纽扣 扣在草原上 我落在一颗纽扣上 风把草压平", 338 },
    { "黄沙里一撮绿","绿洲 新疆和田 高空","05-30", "小鸟邮局",
      "黄沙深处裹着一撮绿 是绿洲 我一头扎下去 葡萄架下有人举起手 对我喊", 339 },
    { "风梳过的波浪","沙丘链 塔克拉玛干 高空","06-01", "小鸟邮局",
      "沙丘是被风梳过的浪 一道追一道 我顺着浪谷飞 沙打得眼睛睁不开", 340 },
    { "绿盘铺满水","荷塘 湖北洪湖 高空","06-03", "小鸟邮局",
      "荷叶把水面铺成绿盘 水珠在盘里滚 我缩在叶底 雨点敲得噼啪响", 341 },
    { "水在草里迷路","苇荡 黑龙江扎龙 高空","06-05", "小鸟邮局",
      "苇荡里 水拐进草里就迷了路 转来转去出不去 我在草尖上跳 一步一步带它", 342 },
    { "绿浪一层推一层","竹林 浙江安吉 高空","06-07", "小鸟邮局",
      "竹林是一片绿浪 一层压一层 我从浪尖钻进去 凉得羽毛倒竖", 343 },
    { "清水里养的花","水仙 福建漳州 冬","06-09", "蝴蝶邮局",
      "水仙泡在清水里 根像胡须 花开在梗的顶端 我落在盆沿 数它有几箭", 344 },
    { "花比叶子多","海棠 四川成都 春","06-11", "蝴蝶邮局",
      "海棠开得比叶子还密 一树粉云 我钻进花里 只露出半只翅膀", 345 },
    { "一串一串的小星","丁香 黑龙江哈尔滨 春","06-13", "蝴蝶邮局",
      "丁香是一串一串的紫星 白的少 我停在串上 整串花 朝我弯了弯", 346 },
    { "香得像糖果","风信子 上海 春","06-15", "蝴蝶邮局",
      "风信子的香像糖果 甜得发腻 我绕着花箭转了三圈 确定不是谁撒了糖", 347 },
    { "花瓣薄得透光","虞美人 江苏扬州 春","06-17", "蝴蝶邮局",
      "虞美人的花瓣薄得能透光 脉络一根根 我把翅膀张开 让日头 透过来", 348 },
    { "心形叶子托着花","紫罗兰 云南 春","06-19", "蝴蝶邮局",
      "紫罗兰把花开在心形的叶子上 像托着一盏灯 我落在灯边 影子都是心的形状", 349 },
    { "一串小铃铛","铃兰 吉林长白 春","06-21", "蝴蝶邮局",
      "铃兰挂下一串串小铃 没风也轻轻晃 我碰了碰最下面那只 它点头给我看", 350 },

    { "红墙上的金顶","布达拉宫 拉萨 晴","10-03", "拉萨",
      "红墙白墙一层一层叠到云里 转经的人绕着走了一圈又一圈 我也跟着走了", 0 },
    { "竹筏上看渔翁","漓江 广西桂林 晴","10-04", "小鸟邮局",
      "我站在竹筏的竿尖上看渔翁撒网 水里有个影子跟你好像 回家讲给你听", 1 },
    { "蓝顶的圆殿","天坛 北京东城 晴","10-06", "北京",
      "蓝瓦在太阳底下亮得晃眼 我沿着长廊慢慢走 檐角的影子一寸一寸挪过去", 2 },
    { "江对岸的塔","外滩 上海黄浦 夜","10-07", "上海",
      "江风把头发吹得乱七八糟 对岸的灯一盏一盏亮起来 船慢慢开过去 把光搅碎", 3 },
    { "断桥不断","西湖 浙江杭州 小雨","10-08", "杭州",
      "桥没断 雨倒是下得挺密 我撑着伞沿湖走 水面上全是圆圈圈的涟漪", 4 },
    { "啃竹子的家伙","熊猫基地 四川成都 晴","10-09", "成都",
      "熊猫抱着竹子啃得津津有味 啃完就往地上一躺 圆滚滚的 看着就想笑", 5 },
    { "城楼下的影子","西安城墙 陕西 晴","10-10", "西安",
      "城楼在太阳底下投了老大一块影子 我沿着城墙根走 脚下的砖晒得发烫", 6 },
    { "沙山上的驼铃","鸣沙山 甘肃敦煌 晴","10-11", "敦煌",
      "骆驼一队一队往沙脊上爬 驼铃叮叮当当 影子被拉得老长 一直排到天边", 7 },
    { "比云还高的地方","黄山 安徽 多云","10-12", "小鸟邮局",
      "松树的尖尖上能看到云的背面 风把我吹得晃了晃 你要是来了得抓紧点", 8 },
    { "月洞门后头","拙政园 江苏苏州 晴","10-13", "苏州",
      "月洞门里藏着另一重院子 荷叶铺满了整个池塘 锦鲤摆着尾 慢慢游过去", 9 },
    { "维港的夜","维多利亚港 中国香港 夜","10-14", "香港",
      "对岸的高楼一幢比一幢亮 天星小轮慢慢晃 风吹得舒服 我靠着栏杆不想走", 10 },
    { "草比我飞得还高","呼伦贝尔 内蒙古 晴","10-15", "小鸟邮局",
      "风把草吹弯的时候 整片草原都在往一边跑 我逆着飞了一会儿 想你啦", 11 },
    { "渔火点点","漓江 广西阳朔 晨","10-16", "阳朔",
      "天刚蒙蒙亮 江面上浮着一层薄雾 竹筏撑着长竿把网撒下去 惊起一串水花", 12 },
    { "水田叠到云里","龙胜梯田 广西 晴","10-17", "龙胜",
      "梯田一层一层往山上叠 水在太阳底下亮晶晶的 牛慢悠悠走 犁出一条长线", 13 },
    { "白墙黑瓦","乌镇 浙江嘉兴 小雨","10-18", "嘉兴",
      "白墙黑瓦排在河两边 石桥拱起来像个半圆 雨丝落在水面上 一圈一圈散开", 14 },
    { "高原上的蓝","青海湖 青海 晴","10-19", "青海湖",
      "湖水蓝得不像话 远处的雪山泡在水里 风从湖面上刮过来 冷得我缩了缩脖子", 15 },
    { "一棵很老很老的树","塔克拉玛干 新疆 晴","10-20", "小鸟邮局",
      "我落在最老的树梢上往远处看 沙子亮得像水 飞过去就能找到下一片绿", 16 },
    { "圆圆的土楼","客家土楼 福建龙岩 晴","10-21", "龙岩",
      "土楼圆圆地扣在地上 屋檐一圈一圈往里收 站在天井里抬头看 天是一小块圆的", 17 },
    { "茶山弯弯","武夷山 福建 晴","10-22", "武夷山",
      "茶垄顺着山势一道一道弯 溪水从石头缝里淌过去 我蹲在溪边洗了把脸", 18 },
    { "胡同里","胡同 北京西城 晴","10-23", "北京",
      "灰砖墙根下蹲着只猫 大爷推着车慢慢过 阳光从屋檐缝里漏下来 一地光斑", 19 },
    { "竹影子里","蜀南竹海 四川宜宾 晴","10-24", "宜宾",
      "竹子长得又高又密 阳光从叶缝里漏下来 风一吹就沙沙响 整片竹林都在说话", 20 },
    { "彩旗在飘","色达 四川甘孜 晴","10-25", "甘孜",
      "山坡上挂满了彩旗 风一吹哗啦啦地响 红衣的僧人慢慢走过 转角的塔金闪闪", 21 },
    { "洱海边","洱海 云南大理 晴","10-26", "大理",
      "湖面平得像块镜子 苍山的影子倒进去 我坐在岸边看了一下午 什么也没想", 22 },
    { "船靠岸了","渔港 福建霞浦 黄昏","10-27", "霞浦",
      "渔船一艘挨着一艘靠在码头 桅杆上的旗被晚风扯得直响 腥味混着饭香飘过来", 23 },
    { "像撒了一地花瓣","丹霞地貌 甘肃张掖 晴","10-28", "蝴蝶邮局",
      "山坡一层一层的红一层一层的黄 我以为是花瓣全落在这里了 就多停了几天", 24 },
    { "叶子比花还好看","山村 安徽宏村 秋","10-29", "蝴蝶邮局",
      "满山的叶子红起来比花园还热闹 我挨片看了看 挑了最好看的一片 想寄给你", 25 },
    { "茶垄一层层","茶园 浙江湖州 晴","10-30", "湖州",
      "茶垄整整齐齐排在坡上 采茶的人低着头弯着腰 太阳晒得暖洋洋 特别安静", 26 },
    { "院子里的大树","大院 山西平遥 晴","10-31", "平遥",
      "院子里种了棵老树 影子铺满半个天井 门楼上的砖雕磨得发亮 岁月都在这儿", 27 },
    { "花田在慢慢转","风车 荷兰 晴","11-03", "蝴蝶邮局",
      "飞过一片花田 风很慢 我也很慢 停在一朵黄色的花上 想起你家窗台", 30 },
    { "炉上的铁壶","铁壶 山西晋中 晴","11-06", "晋中",
      "铁壶坐在炉子上 提梁弯成一道弧 水一开 壶盖就咕咕地往上跳", 32 },
    { "屋里也开着花","花瓶 江苏扬州 晴","11-07", "蝴蝶邮局",
      "窗没关严 我就进来了 瓶里那枝花是假的 可香气是真的 我待了一下午", 33 },
    { "檐下的灯","灯笼 四川自贡 夜","11-08", "自贡",
      "灯笼圆鼓鼓挂在檐下 风一吹就轻轻晃 昏黄的光 把石板路照得暖洋洋", 34 },
    { "墙角的竹篮","竹篮 浙江安吉 晴","11-09", "安吉",
      "竹篮靠在墙角 编得密密的 摸上去有点毛刺 手一按 还咯吱咯吱响", 35 },
    { "灶边的陶罐","陶罐 云南建水 晴","11-10", "建水",
      "陶罐蹲在灶台边 肚子圆滚滚的 盖子一掀 全是酱萝卜的酸香味", 36 },
    { "刚捏的饭团","饭团 浙江嘉兴 晴","11-11", "嘉兴",
      "饭团还带着手心温度 圆圆满满搁在盘上 咬一口 米粒又软又甜", 37 },
    { "茶托上的杯","茶杯 福建安溪 晴","11-12", "安溪",
      "茶汤绿得发亮 热气慢慢往上飘 我捧着小杯 慢慢抿 一坐就是半下午", 38 },
    { "井边的木桶","木桶 江西婺源 晴","11-13", "婺源",
      "木桶搁在井边 桶底还挂着水珠 一弯腰提起来 凉气顺着胳膊往上爬", 39 },
    { "案上的托盘","托盘 广东潮州 晴","11-14", "潮州",
      "托盘上摆着两只小碗 一大一小 摆得齐齐整整 等客人落座才动筷", 40 },
    { "壁上的挂轴","挂轴 江苏南京 晴","11-15", "南京",
      "墙上挂着一幅空白的挂轴 什么也没画 屋子安静下来 反倒觉得满当", 41 },
    { "斜靠的草帽","草帽 广西龙脊 晴","11-16", "龙脊",
      "草帽斜斜靠在木架上 编得松松的 戴上一抬头 能看见一圈毛边的天", 42 },
    { "小桌的酒壶","酒壶 山西汾阳 夜","11-17", "汾阳",
      "酒壶温热 旁边搁一只小杯 灯下影子拖得老长 抿一口 脸就红起来", 43 },
    { "案头的包袱","包袱 云南沙溪 晴","11-18", "沙溪",
      "布包捆得结结实实 绳结打得利落 里面装的是换洗衣裳 还是几本书", 44 },
    { "浅碗里的鱼","鱼 江苏周庄 晴","11-19", "周庄",
      "浅碗里躺着一尾小鱼 线条画得简单 尾巴翘起来 像刚出水还在摆", 45 },
    /* ═══ 第 48..127 张 = 远行明信片 80 张（2026-10-16 上午扩编）═══
       · 照片 = post.bin 下标 47..126（同批并入，两版一致）
       · 京都 12 / 威尼斯 12 / 冰岛 28（含专属 16 张标志性场景）/ 撒哈拉 12 ——
         多备几张，旅途中按天随机抽（用户：「多多益善，不一定全部都发」）
       · 文案 ≤32 字、无全角标点、已过字检；唯一数据源 = scripts/_tools/_gen_post_1016.py */
    { "樱花落了一路",        "樱雨小路 京都 晴",          "11-21",  "京都",
      "樱花开满整条小路 风一过就落一场 我走走停停 鞋底沾了花瓣", 47 },
    { "换车的空档",          "车站月台 京都 多云",        "11-22",  "京都",
      "月台上人来人往 我蹲在长椅底下等车 铁轨一直伸到看不见的地方", 48 },
    { "进来先鞠个躬",        "神社鸟居 京都 晴",          "11-23",  "京都",
      "进门先鞠一躬 石阶被踩得发亮 我跟着人群慢慢往上走 心里很静", 49 },
    { "全是吃食的香味",      "锦市巷子 京都 晴",          "11-24",  "京都",
      "巷子窄窄的 两边全是吃食的香味 我蹲在摊子前看了好久 舍不得走", 50 },
    { "船比车走得慢",        "水上巴士 威尼斯 晴",        "11-25",  "威尼斯",
      "船比车慢多了 一路晃晃悠悠 两边的房子都泡在水里 窗台上摆着花", 51 },
    { "水声一直在响",        "运河拱桥 威尼斯 多云",      "11-26",  "威尼斯",
      "拱桥一个接一个 水声一直在响 我趴在栏杆上看船 看了整整一下午", 52 },
    { "挑了一个给你",        "面具店 威尼斯 晴",          "11-27",  "威尼斯",
      "面具挂了一整面墙 我挑了一个最好看的 想带回家挂在你门上", 53 },
    { "鸽子围着人转",        "圣马可广场 威尼斯 晴",      "11-28",  "威尼斯",
      "广场上好多人 鸽子围着人转 钟楼响了一声 我抬头看了好久", 54 },
    { "飞了好久好久",        "跨洋海面 海上 晴",          "11-29",  "海上",
      "飞了好久好久 底下全是海 云一片一片铺过去 我的爪子都坐麻了", 55 },
    { "落地的第一件事",      "落地机场 中转站 阴",        "11-30",  "中转站",
      "落地第一件事是抖抖毛 玻璃外面停着大飞机 影子比房子还长", 56 },
    { "天上流着光的河",      "极光雪原 冰岛 夜",          "12-01",  "冰岛",
      "雪地上没人 天一黑下来 就有光的河在天上慢慢流 我看了很久很久", 57 },
    { "蓝得发亮",            "冰川 冰岛 晴",              "12-02",  "冰岛",
      "冰是蓝的 蓝得发亮 裂缝深得看不见底 我轻轻走 不敢出大声", 58 },
    { "支了顶帐篷过夜",      "沙漠营地 撒哈拉 夜",        "12-03",  "撒哈拉",
      "支了顶帐篷过夜 火堆烧得噼啪响 沙子白天烫脚 晚上凉得像水", 59 },
    { "一脚踩下去就陷了",    "沙丘 撒哈拉 晴",            "12-04",  "撒哈拉",
      "沙丘一道一道排到天边 一脚踩下去就陷进去 回头看看 我的脚印还在", 60 },
    { "居然有水还有树",      "绿洲 撒哈拉 晴",            "12-05",  "撒哈拉",
      "走了一天 居然有一片水 还有几棵树歪歪地长着 我喝了半天 喝饱了", 61 },
    { "星星多得数不清",      "星空 撒哈拉 夜",            "12-06",  "撒哈拉",
      "天黑之后 星星一颗一颗冒出来 多得数不清 我躺平了看 脖子都酸了", 62 },
    { "架在崖上的大殿",      "清水寺 京都 晴",            "12-07",  "京都",
      "大殿整个架在崖上 底下全是木柱撑着 我趴在栏杆上往下看 腿有点软", 63 },
    { "风一吹就沙沙响",      "岚山竹林 京都 多云",        "12-08",  "京都",
      "竹子高得抬头看不见顶 风一吹就沙沙响 整条小路都在说话", 64 },
    { "水边坐了一排人",      "鸭川 京都 黄昏",            "12-09",  "京都",
      "天快黑的时候 水边坐了一排人 谁也不说话 就看着河水往下游走", 65 },
    { "一个个圆滚滚",        "和果子铺 京都 晴",          "12-10",  "京都",
      "柜台上一排排和果子 圆滚滚的 摆得整整齐齐 我看了半天没舍得走", 66 },
    { "船头翘得老高",        "贡多拉 威尼斯 晴",          "12-11",  "威尼斯",
      "小船船头翘得老高 船夫站在后面撑竿 拐进水巷的时候 墙都快贴着脸", 67 },
    { "一栋一个颜色",        "彩色岛 威尼斯 晴",          "12-12",  "威尼斯",
      "岛上的房子一栋一个颜色 红黄蓝绿挨着排 我挨家挨户看过来 眼睛都花了", 68 },
    { "把整条运河染红",      "桥上 威尼斯 黄昏",          "12-13",  "威尼斯",
      "站在桥上往西看 太阳一点点沉下去 把整条运河都染红了 我看着忘了走", 69 },
    { "腥味混着海水味",      "海鲜市集 威尼斯 晨",        "12-14",  "威尼斯",
      "天刚亮市集就吵起来 鱼虾摆了一排排 腥味混着海水味 我蹲在筐边看了半天", 70 },
    { "一脚踩上去软软的",    "苔原 冰岛 晴",              "12-15",  "冰岛",
      "地上铺着厚厚一层苔 一脚踩上去软软的 远处什么都没有 就一直到天边", 71 },
    { "沙子真是黑的",        "黑沙滩 冰岛 阴",            "12-16",  "冰岛",
      "沙子真是黑的 浪打上来白得晃眼 石头一根根立在海里 跟巨人的手指一样", 72 },
    { "声音先到 水才到",     "大瀑布 冰岛 晴",            "12-17",  "冰岛",
      "还没走到就听见响 水从高处砸下来 溅得满脸都是 我眯着眼看了好久", 73 },
    { "到处在冒白气",        "地热温泉 冰岛 阴",          "12-18",  "冰岛",
      "地上到处在冒白气 水是温的 硫磺味有点冲 我趴在池边泡着不想动", 74 },
    { "一队一队往沙脊上爬",  "骆驼队 撒哈拉 晴",          "12-19",  "撒哈拉",
      "骆驼一队一队往沙脊上爬 铃铛叮叮当当 影子被拉得老长 一直排到天边", 75 },
    { "土墙一层一层往上叠",  "土城 撒哈拉 晴",            "12-20",  "撒哈拉",
      "土墙一层一层往上叠 窗户小小的 巷子里凉快 我顺着坡一路走到了顶上", 76 },
    { "地上白花花一片",      "盐湖 撒哈拉 晴",            "12-21",  "撒哈拉",
      "地上白花花一片 踩上去咯吱响 天倒在水里 分不清哪儿是天哪儿是地", 77 },
    { "像个大窗户",          "岩石拱门 撒哈拉 晴",        "12-22",  "撒哈拉",
      "石头被风吹出一个大洞 像个窗户 我蹲在洞底下躲太阳 看了半天", 78 },
    { "一盏一盏亮起来",      "灯笼铺 京都 黄昏",          "12-23",  "京都",
      "铺子门口挂满纸灯笼 天擦黑的时候一盏一盏亮起来 暖黄暖黄的", 79 },
    { "水从桥洞底下过",      "石桥 京都 晴",              "12-24",  "京都",
      "石桥矮矮的 水从桥洞底下过去 柳枝垂到水面上 风一吹就扫出波纹", 80 },
    { "一院子都是红的",      "庭园 京都 秋",              "12-25",  "京都",
      "一院子都是红的 落叶铺在石头上 砂砾耙出一道道纹 安静得能听见水声", 81 },
    { "窗外一片一片往后退",  "归途列车 京都 晴",          "12-26",  "京都",
      "坐在靠窗的位置 窗外一片一片往后退 我把下巴搁在窗沿上 想家了", 82 },
    { "桥里看得到外面",      "叹息桥 威尼斯 多云",        "12-27",  "威尼斯",
      "桥封得严严实实 只留两个小窗 从里头看得到外面 水光一晃一晃的", 83 },
    { "墙上是湿的",          "小巷 威尼斯 小雨",          "12-28",  "威尼斯",
      "巷子窄得伸开爪子都能碰到两边 墙上是湿的 走到底忽然就是一片水", 84 },
    { "从屋顶上看到一个圆",  "教堂穹顶 威尼斯 晴",        "12-29",  "威尼斯",
      "爬到旁边的屋顶上 正好看见大圆顶 一个一个挨着排 底下全是红瓦", 85 },
    { "船要开了",            "归途码头 威尼斯 晴",        "12-30",  "威尼斯",
      "码头上的柱子拴着旧船 我蹲在边上看行李一件件搬上去 船要开了", 86 },
    { "冰块飘在水上",        "冰河湖 冰岛 阴",            "12-31",  "冰岛",
      "大冰块一块块飘在水面上 慢慢往海里挪 蓝白蓝白的 安静得吓人", 87 },
    { "屋顶上压着厚雪",      "雪原小屋 冰岛 阴",          "01-01",  "冰岛",
      "小屋屋顶上压着厚厚一层雪 烟囱冒着细烟 我在门口蹲着 里面一定很暖", 88 },
    { "一闪一闪到天亮",      "灯塔海岸 冰岛 夜",          "01-02",  "冰岛",
      "灯塔立在一块孤石上 灯一闪一闪转到天亮 浪在底下一下一下拍", 89 },
    { "云在脚底下",          "归途 冰岛 晴",              "01-03",  "冰岛",
      "回来的时候从云上面过 云一层一层铺在脚底下 像一整片白色的地", 90 },
    { "沙子堆成一道一道",    "沙地 撒哈拉 晴",            "01-04",  "撒哈拉",
      "风停之后沙子堆成一道一道 车辙被埋掉一半 我照着原路慢慢走回去", 91 },
    { "火星子往天上飞",      "营地 撒哈拉 夜",            "01-05",  "撒哈拉",
      "围着火坐了一圈 火星子噼啪往天上飞 谁也不急着睡 就那么坐着", 92 },
    { "木头轮子嘎吱响",      "水井 撒哈拉 晴",            "01-06",  "撒哈拉",
      "井边围着人和骆驼 木头轮子嘎吱嘎吱响 一桶水提上来 大家都笑了", 93 },
    { "远远看见几棵棕榈",    "归途绿洲 撒哈拉 晴",        "01-07",  "撒哈拉",
      "走出去好远 远远看见几棵棕榈 我就知道路没走错 脚步一下轻了", 94 },
    { "天上那条河又来了",    "极光 冰岛 夜",              "01-08",  "冰岛",
      "山尖上黑着 天上一整条光河慢慢流 一会儿绿一会儿紫 我忘了眨眼", 95 },
    { "水里全是白气",        "蓝湖 冰岛 阴",              "01-09",  "冰岛",
      "黑色的石头围着一池热水 水里全是白气 我把爪子伸进去 就不想拿出来", 96 },
    { "水拐了个弯往下砸",    "黄金瀑布 冰岛 晴",          "01-10",  "冰岛",
      "水拐了个弯往深沟里砸 轰隆隆响 太阳出来的时候 雾里还有一道彩虹", 97 },
    { "每隔一会儿就喷一次",  "间歇泉 冰岛 晴",            "01-11",  "冰岛",
      "地上一个圆水眼 每隔一会儿就鼓起来 哗地喷起老高 大家一齐叫好", 98 },
    { "一排石头立在浪里",    "黑沙滩 冰岛 阴",            "01-12",  "冰岛",
      "一排黑石头直直立在浪里 浪打过去就散成白末 我退后几步才敢看", 99 },
    { "冰块一直漂到海里",    "冰河湖口 冰岛 阴",          "01-13",  "冰岛",
      "湖口最窄的地方 冰块一块接一块漂进海里 浪一大就撞得咔咔响", 100 },
    { "冰块躺在黑沙上",      "钻石沙滩 冰岛 晴",          "01-14",  "冰岛",
      "一大片冰块躺在黑沙上 太阳一照亮得像碎了满地玻璃 我绕着走了一圈", 101 },
    { "裂缝里是蓝的",        "冰川 冰岛 晴",              "01-15",  "冰岛",
      "冰川一直伸到山脚下 表面灰扑扑的 裂缝里却蓝得发亮 静静的不敢碰", 102 },
    { "一圈红土围着一汪水",  "火山口湖 冰岛 多云",        "01-16",  "冰岛",
      "爬上去才看见 一圈红土围着一汪水 水面一动不动 底下不知道有多深", 103 },
    { "屋顶上长着草",        "草皮教堂 冰岛 晴",          "01-17",  "冰岛",
      "小教堂屋顶上长着草 旁边一道细瀑布 风一吹草就倒向一边 特别安静", 104 },
    { "鬃毛长得遮住眼睛",    "牧马场 冰岛 晴",            "01-18",  "冰岛",
      "一匹匹矮墩墩的马 鬃毛长得遮住眼睛 走近了就凑过来闻我 温温热热的", 105 },
    { "像一截石头山",        "大教堂 冰岛 晴",            "01-19",  "冰岛",
      "教堂高高地立在山坡上 一层一层往上收 像一截石头山 街上人都很小", 106 },
    { "一架破飞机趴在黑沙上", "飞机残骸 冰岛 阴",          "01-20",  "冰岛",
      "一架破飞机趴在黑沙上 翅膀断了一半 四周什么都没有 风大得站不住", 107 },
    { "水从崖上直直落下来",  "路边瀑布 冰岛 晴",          "01-21",  "冰岛",
      "车停在路边 水从崖上直直落下来 后面有一道能走进去的小路 我走了一半", 108 },
    { "一群小胖鸟站在草坡上", "海鹦崖 冰岛 晴",            "01-22",  "冰岛",
      "一群小胖鸟站在草坡上 嘴花花绿绿的 走起路来一摇一摆 我看了半天", 109 },
    { "房子都朝着海",        "渔村 冰岛 晴",              "01-23",  "冰岛",
      "小村子夹在两条山脊之间 房子都朝着海 红屋顶一片 船拴在门口", 110 },
    { "一条红色的长廊",      "伏见稻荷 京都 晴",          "01-24",  "京都",
      "一根挨一根的红柱子排成一条长廊 走进去光都变红了 走到一半就想回头", 111 },
    { "金闪闪地浮在水上",    "金阁寺 京都 晴",            "01-25",  "京都",
      "房子金闪闪地浮在水上 倒影清清楚楚 我蹲在池边看了半天 一动不敢动", 112 },
    { "整座堂架空在山坡上",  "本堂 京都 多云",            "01-26",  "京都",
      "整座堂架空在山坡上 底下一百多根柱子 从下面往上看 像悬在半空中", 113 },
    { "木格子门窗一家接一家", "花见小路 京都 黄昏",        "01-27",  "京都",
      "木格子门窗一家接一家 灯笼刚点上 远远有人踩着木屐走过 嗒嗒响", 114 },
    { "桥横在河上 山在桥后", "渡月桥 京都 晴",            "01-28",  "京都",
      "长桥横在河上 山就在桥后头 云慢慢从山后冒出来 我靠在栏杆上发呆", 115 },
    { "塔尖冒在屋瓦上面",    "五重塔 京都 晴",            "01-29",  "京都",
      "塔尖一层一层往上收 冒在一片屋瓦上头 从巷子里看过去 格外显眼", 116 },
    { "桥上全是人",          "里亚托桥 威尼斯 晴",        "01-30",  "威尼斯",
      "桥拱得高高的 桥上全是人 底下大船小船一条接一条从桥洞里穿过去", 117 },
    { "金闪闪的顶子",        "圣马可 威尼斯 晴",          "01-31",  "威尼斯",
      "教堂正面一圈金闪闪的顶子 里头暗 点着灯 我贴着墙根慢慢挪了一圈", 118 },
    { "两栋楼之间搭着一条小桥", "叹息桥 威尼斯 黄昏",        "02-01",  "威尼斯",
      "两栋楼之间高高搭着一条小桥 从外侧看更清楚 船从底下过的时候我抬头", 119 },
    { "水巷里也五颜六色",    "彩色岛 威尼斯 晴",          "02-02",  "威尼斯",
      "水巷两边的墙也是五颜六色的 小船停在门口 窗台上一排花盆", 120 },
    { "一排圆顶挨着排",      "金顶教堂 威尼斯 晴",        "02-03",  "威尼斯",
      "从桥上正好看见正面 一排圆顶挨着排 顶上还有金闪闪的小十字", 121 },
    { "大船小船挤在一处",    "大运河 威尼斯 晴",          "02-04",  "威尼斯",
      "大运河又宽又热闹 大船小船挤在一处 浪一拍 两边的船都晃起来", 122 },
    { "黄色的塔楼一座座",    "古堡 撒哈拉 晴",            "02-05",  "撒哈拉",
      "一整面山坡上全是土墙和黄塔楼 密密挨着 我顺着小路上到顶 风真大", 123 },
    { "一行影子拖在沙上",    "驼道 撒哈拉 黄昏",          "02-06",  "撒哈拉",
      "太阳快落下去 驼队一行走在沙脊上 影子长长拖在沙上 铃铛轻轻响", 124 },
    { "就一棵树站着",        "沙地 撒哈拉 晴",            "02-07",  "撒哈拉",
      "整整一片沙里就一棵枯树站着 影子也只有一道 我绕着它走了一圈", 125 },
    { "一条银河横在头顶",    "沙丘 撒哈拉 夜",            "02-08",  "撒哈拉",
      "半夜醒来 一条银河横在头顶 沙丘黑黑地趴着 我躺着看到天快亮", 126 },
/* ══ 2026-10-25 三.3：新批 432 张之「异国 208」追加表尾（含 6 新目的地，exp_post_index_build 自动分组）══ */
    { "石柱站在浪里","玄武岩海岸 冰岛 晴","06-25", "冰岛",
      "浪一层层撞上来 碎成白沫 石柱排成管风琴 海水在孔里嗡嗡响", 351 },
    { "荒原上一户人家","苔原木屋 冰岛 多云","06-27", "冰岛",
      "苔原一直铺到天边 一栋红屋蹲在风里 烟囱冒着一缕白气 狗叫声被风吹散", 352 },
    { "两边的水都在落","峡湾 冰岛 多云","06-29", "冰岛",
      "两边的山壁笔直插进水里 小船贴着崖根走 头顶只剩一条窄的天", 353 },
    { "黑石头也在冒气","熔岩原 冰岛 阴","07-01", "冰岛",
      "黑石头上蒙着一层白霜 地热从缝里往外冒 踩上去 地面是温的", 354 },
    { "沙地扫出了波纹","银阁寺 京都 晴","07-03", "京都",
      "耙齿一道道梳过银沙滩 波纹追着耙齿跑 僧人每天重新画一遍大海", 355 },
    { "石头浮在白砂上","龙安寺 京都 晴","07-05", "京都",
      "十五块石头 怎么看都数不全 苔藓边缘发黑 像墨滴在宣纸上", 356 },
    { "红砖拱渠架在林间","南禅寺 京都 晴","07-07", "京都",
      "红砖一道叠一道 通水的渠从树梢下穿过 苔痕爬上砖缝 水声在林子深处", 357 },
    { "踏石一路点到水边","桂离宫 京都 晴","07-09", "京都",
      "踏石隔一步放一块 鞋尖要挑准了落 影子先一步踩进水里", 358 },
    { "墙像镂空的花边","总督府 威尼斯 晴","07-11", "威尼斯",
      "白石雕成镂空的纹样 尖顶一叠一叠往上升 乌鸦在最高的拱上落脚", 359 },
    { "炉火边吹一只杯","玻璃岛 威尼斯 晴","07-13", "威尼斯",
      "炉火一千二百度不熄 铁管吹一口气 杯子圆滚滚地长出来", 360 },
    { "对岸立着圆顶","圣乔治岛 威尼斯 晴","07-15", "威尼斯",
      "水面把圆顶摇成两半 贡多拉的桨一起一落 钟声从对岸追过来", 361 },
    { "瓦片铺到水边","屋顶 威尼斯 晴","07-17", "威尼斯",
      "橙红色的瓦一直铺到水沿 窗框漆成绿的 绳子拴着晾衣杆 探到运河上方", 362 },
    { "沙子从中心炸开","星形沙丘 撒哈拉 高空","07-19", "撒哈拉",
      "风从背坡爬上来 沙粒沿着脊线奔跑 站在最高点 影子短得贴不住地", 363 },
    { "巷子窄得只过一人","沙漠村落 撒哈拉 晴","07-21", "撒哈拉",
      "土墙夹着一条窄缝 羊从身边挤过去 屋顶上晒着椰枣", 364 },
    { "树影底下有条沟","椰枣林 撒哈拉 晴","07-23", "撒哈拉",
      "椰枣把影子铺在沙上 水沟顺着树根绕 井绳磨出了一道深槽", 365 },
    { "全都抬起头看我","羊群 冰岛 晴","07-27", "冰岛",
      "草刚冒尖 羊群一齐停下咀嚼 几十双眼睛转过来 风还在吹它们的毛", 366 },
    { "它们躺得比我舒服","海豹滩 冰岛 多云","07-29", "冰岛",
      "礁石上横着七八条海豹 尾巴拍一下水 又摊开 鼾声比浪还响", 367 },
    { "从边上往下看一圈","火山口 冰岛 多云","07-31", "冰岛",
      "火山口像只绿碗 水纹一圈圈荡开 岩壁上挂着白霜 脚步不自觉地往后退", 368 },
    { "冰是蓝色的","冰洞 冰岛 晴","08-02", "冰岛",
      "冰层把光滤成蓝的 深处裂开一道缝 水滴丁冬 比冬天更冬天", 369 },
    { "柱子一眼数不完","长殿 京都 多云","08-04", "京都",
      "柱子一根根排过去 光线在柱身上切出明暗 数到二十就乱了 脚步声在殿里来回", 370 },
    { "坡道两边全是老店","石坂小路 京都 晴","08-06", "京都",
      "石板被脚底磨得发亮 门帘一家接一家 木格窗里伸出半盆绣球", 371 },
    { "石阶一直往上走","贵船神社 京都 阴","08-08", "京都",
      "石阶夹在两排红灯之间 数到三百级 鞋底沾了露水 灯笼在风里点头", 372 },
    { "踩着石头过河","鸭川跳石 京都 晴","08-10", "京都",
      "跳石一只只摆进浅滩 高中生卷着裤脚 羽毛球从河滩飞过去", 373 },
    { "船翻过来在修","船坞 威尼斯 晴","08-12", "威尼斯",
      "贡多拉肚皮朝上躺在架上 刨花卷成筒 新漆味盖过了鱼腥味", 374 },
    { "衣服晾在河上头","水巷 威尼斯 晴","08-14", "威尼斯",
      "晾衣绳从这头拉到那头 T 恤滴着水 落进运河 晕开一小片油亮", 375 },
    { "书堆在船里","水上书店 威尼斯 晴","08-16", "威尼斯",
      "小船改装成书架 文学和历史挤在一层 猫趴在但丁的头顶", 376 },
    { "这里没有游人","后水巷 威尼斯 多云","08-18", "威尼斯",
      "水面浮着落叶 窗台裂缝里长草 只听见自己的脚步 在砖墙上回响", 377 },
    { "耳朵比脸还大","耳廓狐 撒哈拉 晴","08-20", "撒哈拉",
      "耳朵竖起来 有脸的两倍大 沙地上只剩一对眼睛 和两道爪印", 378 },
    { "一面墙推过来了","沙暴 撒哈拉 阴","08-22", "撒哈拉",
      "黄褐色的墙从地平线立起来 骆驼卧倒 头朝里 尾巴啪嗒啪嗒抽打", 379 },
    { "石缝里藏着一汪水","峡谷绿潭 撒哈拉 晴","08-24", "撒哈拉",
      "岩壁拧成一股麻花 潭水静得发暗 青蛙突然叫了一声 整个峡谷都在听", 380 },
    { "路直得像画上去的","荒原公路 冰岛 晴","08-28", "冰岛",
      "公路在苔原上拉一条直线 开了半天 没有一辆对向车 云比车跑得快", 381 },
    { "红屋顶挤在山脚下","峡湾小镇 冰岛 多云","08-30", "冰岛",
      "红屋顶一栋压一栋 一直堆到坡顶 教堂的尖顶从屋顶林里探出来", 382 },
    { "河是灰白色的","冰川末端 冰岛 阴","09-01", "冰岛",
      "冰川塌下一块 掉进灰白色的河 冰渣互相磕碰 像玻璃在碗里响", 383 },
    { "浪从石拱里穿过去","海蚀拱 冰岛 晴","09-03", "冰岛",
      "海浪挤进石拱 轰地撞在里面的墙上 退下来时 拖着一条白胡子", 384 },
    { "白墙松影","御所 京都 晴","09-05", "京都",
      "白墙圈住一大片空地 松影印在墙上 风一起 墙上的枝头动一下", 385 },
    { "柳条扫着水面","白川 京都 晴","09-07", "京都",
      "柳条垂到水面 一点 就荡开一圈 白鹭单腿站着 盯住水里的影子", 386 },
    { "铁轨两边都是花","旧铁道 京都 春","09-09", "京都",
      "铁轨缝里长出野花 春天把沿途染成粉色 枕木间的石子 被太阳晒得发白", 387 },
    { "堂在水里又立一遍","平等院 京都 晴","09-11", "京都",
      "正殿浮在池心 水纹把倒影揉皱 凤凰的尾巴指向对岸的柳", 388 },
    { "木桥弯过河面","学院桥 威尼斯 晴","09-15", "威尼斯",
      "木拱桥背着栏杆跨过去 台阶被膝盖磨圆 大运河水在桥墩下翻身", 389 },
    { "八角的大圆顶","安康教堂 威尼斯 晴","09-17", "威尼斯",
      "白色大理石一圈圈拧上去 棱线收敛到一个尖 钟锤荡出来 声音铺满广场", 390 },
    { "小艇钻进窄巷","救护艇 威尼斯 晴","09-19", "威尼斯",
      "橙色的艇擦着墙根拐进巷子 桨收了 用手推墙转身 水面窄得刚够过", 391 },
    { "风把沙梳过了","沙纹 撒哈拉 晴","09-21", "撒哈拉",
      "一夜风把沙面梳成瓦楞 沙脊尖上泛着金光 脚一踩 整片波纹改样", 392 },
    { "它在石头上晒背","蜥蜴 撒哈拉 晴","09-23", "撒哈拉",
      "蜥蜴摊成薄薄一片 肚子贴着烫石头 手指伸过去 它嗖地钻进缝", 393 },
    { "地裂成一块一块","盐沼 撒哈拉 晴","09-25", "撒哈拉",
      "盐壳裂成六角形的块 缝里能望到底 白得晃眼 像碎了一地的瓷", 394 },
    { "石头谷里飞满灯笼","卡帕多奇亚 土耳其 晴","09-29", "土耳其",
      "天没亮 谷里升起上百只灯笼 橙色的火苗舔着纸 岩柱的影子一动不动", 395 },
    { "烟囱长在石头上","奇岩谷 土耳其 晴","10-01", "土耳其",
      "岩顶戴一顶石灰帽 像烟囱从土里长出来 手指能抠下一撮白粉", 396 },
    { "岩壁上全是小洞","鸽子谷 土耳其 多云","10-03", "土耳其",
      "岩壁挖成几千个小方格 鸽子进进出出 粪迹把石头染成粉白", 397 },
    { "两个大洲之间","海峡大桥 土耳其 晴","10-05", "土耳其",
      "桥从欧洲跨到亚洲 两侧各立一塔 游轮从桥下钻过 汽笛替两岸问好", 398 },
    { "山脊上的石头城","马丘比丘 秘鲁 多云","10-07", "秘鲁",
      "城嵌在山脊上 梯田一级级托住它 云从脚下过 太阳出来时 整个遗址在冒汽", 399 },
    { "睫毛长得挡眼睛","羊驼 秘鲁 晴","10-09", "秘鲁",
      "睫毛长得挡住了视线 它偏过头 从额头的卷毛缝里打量人 嘴角沾着一点草屑", 400 },
    { "石头咬着石头","库斯科 秘鲁 晴","10-11", "秘鲁",
      "巨石互相咬住 不用灰也缝不起来 刀片都塞不进 西班牙人看了直摇头", 401 },
    { "船是草捆出来的","的的喀喀湖 秘鲁 晴","10-13", "秘鲁",
      "香蒲草一捆捆扎成船 头翘得老高 划起来 水从草缝里渗进来", 402 },
    { "比想象里还大","金字塔 埃及 晴","10-15", "埃及",
      "一块石头有两人高 抬腿往上爬 腿肚子转筋 塔顶在云里 只剩下一个尖", 403 },
    { "它望着远方","狮身人面 埃及 晴","10-17", "埃及",
      "鼻子已经塌了 身子半埋在沙里 眼睛望着日出的方向 一坐三千年", 404 },
    { "帆是三角形","尼罗河 埃及 晴","10-19", "埃及",
      "三角帆兜住北风 船逆流往上走 桅杆弯成一张弓 岸边的椰枣一排排退后", 405 },
    { "柱子比楼还粗","神庙石柱 埃及 阴","10-21", "埃及",
      "石柱要五人合抱 柱身刻满象形文字 阳光从柱间漏下来 一地横七竖八", 406 },
    { "墙都是蓝的","蓝城 摩洛哥 晴","10-23", "摩洛哥",
      "巷子刷成深浅不一的蓝 猫从蓝墙上走过 油漆桶扔在墙角 蓝得发甜", 407 },
    { "土堆成一座城","土堡 摩洛哥 晴","10-25", "摩洛哥",
      "土墙一重套一重 城门低得低头才能进 墙缝里插着碎陶片 太阳一晒 满城泛红", 408 },
    { "一口一口大染缸","染坊 摩洛哥 阴","10-27", "摩洛哥",
      "靛蓝的大缸排成阵 工人踩在布上 胳膊染得比天还蓝 薄荷叶塞给游客 遮那股味", 409 },
    { "山坡像铺了雪","棉花堡 土耳其 晴","10-29", "土耳其",
      "钙华一层层凝成梯田 水从上面漫下来 脚底又滑又温 远处看 山坡在冒白烟", 410 },
    { "柱子一路排到头","以弗所 土耳其 晴","10-31", "土耳其",
      "廊柱一排排立着 断的断 倒的倒 图书馆的门脸还完整 猫从塞尔苏斯脚下经过", 411 },
    { "圆顶大得吓人","大教堂 土耳其 多云","11-02", "土耳其",
      "穹顶罩在整个城市头上 站在下面 人影小得像蚂蚁 回声要转三圈才落定", 412 },
    { "塔守着海湾","加拉塔 土耳其 晴","11-04", "土耳其",
      "石塔顶着圆锥顶 电梯直送顶层 金角湾在脚底下铺开 船小得像纸片", 413 },
    { "山是一层一层的","彩虹山 秘鲁 晴","11-06", "秘鲁",
      "矿脉把山染成一条条色带 红黄绿白 排队上山的人 扶着栏杆喘", 414 },
    { "沙地上画着蜂鸟","地画 秘鲁 高空","11-08", "秘鲁",
      "几公里长的线条 站在山上才看出是蜂鸟 风吹不断 雨冲不掉 千年了还在", 415 },
    { "一格一格全是白","盐池 秘鲁 晴","11-10", "秘鲁",
      "盐田切成几千个小格 灌满水 晒成盐 每格颜色深浅不同 像调色盘", 416 },
    { "缝里插不进纸","印加石墙 秘鲁 阴","11-12", "秘鲁",
      "石头打磨得互相咬合 纸片塞不进缝 地震来了 墙会晃 不会倒", 417 },
    { "坐了两千年","巨像 埃及 晴","11-14", "埃及",
      "巨像并排坐着 脸缺了一块 风沙把腿埋到膝 拉美西斯的名字 刻在脚踝上", 418 },
    { "塔尖挤在一起","老城屋顶 埃及 晴","11-16", "埃及",
      "宣礼塔的尖顶挤成一堆 窗户探出来 晾衣绳横过巷子 从这栋搭到那栋", 419 },
    { "水牛在泥塘里","尼罗河村 埃及 晴","11-20", "埃及",
      "水牛只露个脑袋 耳朵赶着苍蝇 孩子在塘里洗澡 鸬鹚站在牛背上", 420 },
    { "广场上先听见它","宣礼塔 摩洛哥 晴","11-22", "摩洛哥",
      "唤礼声从塔顶漫下来 鸽子惊飞 广场上的人停下脚步 面朝麦加的方向", 421 },
    { "院子中央一池水","庭院 摩洛哥 晴","11-24", "摩洛哥",
      "四面回廊围着一池静水 池底铺满瓷砖 脚步声被水吸走 只剩喷泉在响", 422 },
    { "一堆一堆小山","香料摊 摩洛哥 晴","11-26", "摩洛哥",
      "辣椒堆成小山 藏红花装在陶罐 指尖捻一点 闻一下 打了个喷嚏", 423 },
    { "教堂是从石头里凿的","岩窟教堂 土耳其 多云","11-28", "土耳其",
      "整座教堂从岩柱里掏出来 穹顶上还留着笔画 修士点起蜡烛 墙壁开始呼吸", 424 },
    { "光从星星眼里漏","浴室穹顶 土耳其 晴","11-30", "土耳其",
      "穹顶钻了很多小孔 光从孔里漏下来 斑点落在浴室的大理石上 蒸汽托着它们飘", 425 },
    { "长长的拱顶走廊","巴扎 土耳其 晴","12-02", "土耳其",
      "拱顶一条接一条 灯火串成长线 铜器叮当 茶水沏到第二泡 讨价还在拉锯", 426 },
    { "先鼓起半个身子","热气球 土耳其 黎明","12-04", "土耳其",
      "火舌一点 球囊鼓起半个身子 摇摇晃晃离地 影子在山谷里追着跑", 427 },
    { "台阶伸进云里","印加古道 秘鲁 雾","12-06", "秘鲁",
      "石阶一级级伸进云里 走了四天 嗓子冒烟 云散时 遗址突然出现在脚下", 428 },
    { "拱廊下好乘凉","广场 秘鲁 晴","12-08", "秘鲁",
      "拱廊一圈围着广场 长椅坐满了人 卖气球的小贩松了手 一只红气球升上去", 429 },
    { "两岸绿得看不见边","丛林河 秘鲁 晴","12-10", "秘鲁",
      "两岸的绿密得不透光 河湾处 树枝垂到水面 猴子隔着林冠互相喊", 430 },
    { "浪拍在崖下","利马海岸 秘鲁 多云","12-12", "秘鲁",
      "崖壁被浪啃出缺口 白沫在崖根打转 海鸥顺着风滑 翅膀定在半空", 431 },
    { "倒着躺了几千年","方尖碑 埃及 晴","12-14", "埃及",
      "方尖碑横躺在沙漠里 象形文字朝上 几千年的风沙 把它磨得发哑", 432 },
    { "鹭站在芦苇上","尼罗河 埃及 晴","12-16", "埃及",
      "白鹭单脚站在苇尖 苇秆弯成一张弓 它盯着水面 一动不动 鱼漂过来", 433 },
    { "沙漠边一座白的","小清真寺 埃及 晴","12-18", "埃及",
      "白房子孤零零立在沙边 圆顶刷得雪白 风把沙堆到墙根 门却擦得很干净", 434 },
    { "它在水槽边站着","骆驼 埃及 晴","12-20", "埃及",
      "骆驼站在水槽边 鼻子伸进水里 喝完 抬起头 睫毛上挂着水珠", 435 },
    { "房子叠在山坡上","山村 摩洛哥 晴","12-22", "摩洛哥",
      "土房顺着坡一层层叠上去 屋顶就是上面那家的院子 烟从第三层飘出来", 436 },
    { "塔吉锅摆了一排","陶坊 摩洛哥 晴","12-24", "摩洛哥",
      "尖顶的塔吉锅摆成一排 陶土还带着潮气 师傅的指甲缝里 嵌着洗不掉的红泥", 437 },
    { "门洞像马蹄","老城门 摩洛哥 晴","12-26", "摩洛哥",
      "城门洞是马蹄形的 石头被手摸得发亮 洞里穿堂风 夏天坐满了乘凉的人", 438 },
    { "辣椒晒在毯子上","屋顶 摩洛哥 晴","12-28", "摩洛哥",
      "屋顶铺满毯子 辣椒串成辫子垂下来 猫在毯子中间 挑阴凉的地方卧", 439 },
    { "海鸥追着渡轮飞","博斯普鲁斯 土耳其 晴","07-27", "土耳其",
      "渡轮切开水面 海鸥追着浪里的面包 翅膀掠过大索桥 岸边的茶冒着热气", 440 },
    { "院子中央一座水亭","清真寺庭院 土耳其 晴","07-29", "土耳其",
      "亭子立在院子正中 四壁开着拱门 信徒踩着池沿 俯身洗手 水纹揉乱了倒影", 441 },
    { "门上贴着花砖","宫殿大门 土耳其 晴","07-31", "土耳其",
      "蓝瓷砖拼满整面门墙 郁金香纹样一圈圈 门环擦得锃亮 日头一移 满墙都是水色", 442 },
    { "拱顶下面全是铺子","大巴扎 土耳其 晴","08-02", "土耳其",
      "拱顶罩着几百家铺子 铜灯一盏挨一盏 讨价的声音撞在顶上 又弹回人堆里", 443 },
    { "两层高的石门面","古图书馆 土耳其 晴","08-04", "土耳其",
      "石门脸两层高 科林斯柱撑着檐 裂缝从门楣爬到顶 里面的书 早搬空了", 444 },
    { "木头马站在广场上","特洛伊 土耳其 晴","08-06", "土耳其",
      "空心的木马立在沙滩上 梯子搭在肚子边 爬进去 木板里还留着松脂味", 445 },
    { "房间凿在石头里","洞穴旅店 土耳其 晴","08-08", "土耳其",
      "房间整个凿在岩柱里 床是岩石雕的 窗帘一拉 分不出白天黑夜", 446 },
    { "小路绕着石笋转","玫瑰谷 土耳其 多云","08-10", "土耳其",
      "石笋一根根戳在天上 小路绕着它们转 影子被夕阳拉长 一直拖到谷口", 447 },
    { "小板凳上冒着热气","茶馆 土耳其 晴","08-12", "土耳其",
      "铜茶壶在炉上咕嘟 小茶杯排成一列 棋子落在木盘上 啪的一声", 448 },
    { "裙子张开像一朵花","旋转舞 土耳其 晴","08-14", "土耳其",
      "黑袍旋开成一把伞 双臂一上一下 鼓点越来越密 帽子上的穗 甩成圆圈", 449 },
    { "罗马塔守着码头","老港 土耳其 晴","08-16", "土耳其",
      "石砌的古塔立在码头边 渔船围着它转 塔影伸进水里 缆绳拴在塔根", 450 },
    { "一排石头脑袋坐着","内姆鲁特 土耳其 多云","08-18", "土耳其",
      "石头脑袋排成一行 脸都朝着日出 鹰钩鼻还剩半个 风化把肩膀啃平了", 451 },
    { "毯子从墙上垂下来","地毯店 土耳其 晴","08-20", "土耳其",
      "地毯从墙上垂到地 结是手一个个打的 店主抖开一条 灰尘在光柱里跳舞", 452 },
    { "叮叮当当开过街","老电车 土耳其 晴","08-22", "土耳其",
      "红电车叮叮当当爬上坡 铃铛一路响 广告牌挂在车顶 树影在车身上滑", 453 },
    { "石柱泡在水里","温泉遗迹 土耳其 多云","08-24", "土耳其",
      "罗马的石柱立在水里 一半绿苔一半白 鱼从柱基游过 温泉气从水面冒", 454 },
    { "广场边的大教堂","库斯科 秘鲁 晴","08-26", "秘鲁",
      "教堂占着广场一角 钟声敲响时 广场的鸽子一齐飞 绕着钟楼打转", 455 },
    { "梯田里藏着村子","圣谷 秘鲁 晴","08-28", "秘鲁",
      "梯田一级级盘上山腰 村子藏在田那头 炊烟和雾气 混在一起升", 456 },
    { "石头一层层上去","欧雁台 秘鲁 多云","08-30", "秘鲁",
      "石墙一级级盘上坡顶 缝里插着草 牛走在墙头的小路上 铃铛声滚下来", 457 },
    { "门那头是云海","太阳门 秘鲁 雾","09-01", "秘鲁",
      "石框门立在岩脊上 跨过去 脚下全是云 云缝里 露出一截古道", 458 },
    { "雪顶倒在水里","瓦拉斯 秘鲁 晴","09-03", "秘鲁",
      "雪顶掉进湖里 蓝白各占一半 波纹一荡 雪顶碎成千万片 又拼回去", 459 },
    { "海鸟贴着崖飞","帕拉卡斯 秘鲁 晴","09-05", "秘鲁",
      "海鸟贴着崖壁飞 翅膀几乎碰到岩面 叫声被风吹散 崖下 浪在炸开", 460 },
    { "沙地上趴着大蜘蛛","地画 秘鲁 高空","09-07", "秘鲁",
      "站在观景台上才看清 沙里趴着一只大蜘蛛 八条腿伸出去 有几公里长", 461 },
    { "吊桥搭在树顶上","雨林 秘鲁 晴","09-09", "秘鲁",
      "吊桥悬在树冠之间 木板一格一格漏光 走到中段 桥比树摇得还欢", 462 },
    { "木头阳台雕满花","利马老城 秘鲁 晴","09-11", "秘鲁",
      "木阳台一扇扇探到街上 雕花密得数不清 晾衣绳从阳台绕过巷子 挂着床单", 463 },
    { "白石头墙上挂着花","阿雷基帕 秘鲁 晴","09-13", "秘鲁",
      "白火山岩砌的墙 缝隙开着红花 藤蔓从墙头爬下来 把整条街捂绿", 464 },
    { "红得像一团火","雨林 秘鲁 晴","09-15", "秘鲁",
      "树丛里突然亮起一片红 巨嘴鸟探出头 嘴比脸还大 阳光把羽毛点着", 465 },
    { "线在她手里排彩虹","织布 秘鲁 晴","09-17", "秘鲁",
      "纺锤转得飞快 纬线一排排织进去 彩虹在她膝上一格一格铺开", 466 },
    { "钟楼比树高一点","高原教堂 秘鲁 多云","09-19", "秘鲁",
      "白石教堂立在高原上 钟楼刚高过树梢 钟摆荡起来 半个山谷都听见", 467 },
    { "岛是芦苇捆的","浮岛 秘鲁 晴","09-21", "秘鲁",
      "岛是芦苇捆出来的 走在上面 脚下渗出水 风过处 满岛沙沙响", 468 },
    { "车辙爬满沙坡","沙漠冲沙 秘鲁 晴","09-23", "秘鲁",
      "越野车沿着沙脊往上冲 车辙织成一张网 到顶 停一秒 又俯冲下去", 469 },
    { "一级一级到顶","金字塔 埃及 晴","09-25", "埃及",
      "台阶一级级收上去 到顶只剩一块平台 太阳把石头晒得发烫 影子缩成一步长", 470 },
    { "门比楼还高","神庙塔门 埃及 晴","09-27", "埃及",
      "塔门高得像一面墙 墙上刻满法老的名字 门缝里漏出风 沙子堆到门槛", 471 },
    { "三层台地贴着崖","哈特谢普苏特 埃及 晴","09-29", "埃及",
      "三层台地一层层退上去 柱子排在每层的檐下 崖壁把整座庙衬得又瘦又高", 472 },
    { "船驮着车过河","尼罗河 埃及 晴","10-01", "埃及",
      "渡轮甲板上停满小巴 车头顶着车尾 发动机哼着 河面被推成两道浪", 473 },
    { "窗户探出街两边","老开罗 埃及 晴","10-03", "埃及",
      "木窗一格格探到街心上头 花盆挂在窗沿 晒衣竹横过街道 几乎碰着对面", 474 },
    { "灯笼一串串亮","铜器摊 埃及 晴","10-05", "埃及",
      "铜灯笼挂成一串串 烛火在孔里跳舞 师傅拿小锤敲 叮叮叮 敲出一条边", 475 },
    { "水车慢慢转","灌渠 埃及 晴","10-07", "埃及",
      "水车轱辘轱辘转 木斗子舀水 倒进渠里 渠水顺着田埂 一路小跑", 476 },
    { "石头长成蘑菇","白沙漠 埃及 晴","10-09", "埃及",
      "白石头顶着个大脑袋 风从底部啃 脖子越来越细 像一群站着的蘑菇", 477 },
    { "山比修道院高得多","西奈山 埃及 多云","10-11", "埃及",
      "修道院缩在山脚下 石头墙贴着岩壁 登山的人打着手电 天没亮就出发", 478 },
    { "帆船都收了帆","阿斯旺 埃及 晴","10-13", "埃及",
      "三角帆一只只降下来 桅杆排成栅栏 船工蹲在船头 补上午磨破的帆", 479 },
    { "连神都长着猫脸","猫神像 埃及 晴","10-15", "埃及",
      "青铜猫端坐在台座上 耳尖镶着金环 眼睛描成绿的 尾巴绕到身前", 480 },
    { "纸一张张晾着","莎草纸坊 埃及 晴","10-17", "埃及",
      "莎草剖成薄片 交叉着压平 一张张排在架上 压出的纹路 像编织的席子", 481 },
    { "陶罐一排排灌满","村口水井 埃及 晴","10-19", "埃及",
      "陶罐排在井台上 绳子一上一下 孩子提着罐跑 水在罐口晃成半个满月", 482 },
    { "月亮爬得很低","月夜沙丘 埃及 晴","10-21", "埃及",
      "月亮低得压着沙脊 影子朝一边躺 沙面泛着银光 脚印被照成一道道槽", 483 },
    { "沙子快爬上门楣","半埋神庙 埃及 多云","10-23", "埃及",
      "沙子堆到柱子一半 门楣被埋得只剩一条缝 挖出来的台阶 又被埋回去", 484 },
    { "大西洋就在墙外","海滨大道 摩洛哥 晴","10-25", "摩洛哥",
      "城墙把海挡在外头 炮台探出墙外 浪花拍上城墙 散步的人靠着墙根走", 485 },
    { "驴驮着货走巷子","老城巷 摩洛哥 晴","10-27", "摩洛哥",
      "驴子驮着整袋面粉挤过巷子 脖子上的铃铛一路响 人贴着墙让 蹄子敲在石板上 得得得", 486 },
    { "蓝墙前全是刺","马约尔花园 摩洛哥 晴","10-29", "摩洛哥",
      "靛蓝的墙前 仙人掌排成队 刺在太阳下发光 竹丛从墙头探出来 风一碰就摇一阵", 487 },
    { "路在山脊上绕","阿特拉斯山口 摩洛哥 晴","10-31", "摩洛哥",
      "公路沿着山脊盘 拐弯处竖着牌子 提醒有落石 羊群站在路中间 不让车", 488 },
    { "炮口对着河口","乌达雅堡 摩洛哥 晴","11-02", "摩洛哥",
      "古炮排在城垛上 锈成了褐色 炮口齐齐指着河口 海鸥落在炮管上 理羽毛", 489 },
    { "蓝船挤在一起","索维拉 摩洛哥 多云","11-04", "摩洛哥",
      "蓝木船一条挨一条 船头漆着花纹 渔网晒在船帮 海鸥等着 捡漏", 490 },
    { "茶要高高倒","薄荷茶 摩洛哥 晴","11-06", "摩洛哥",
      "铜壶举过头顶 茶线细细地落 杯里泛起一层白沫 薄荷叶在杯底打转", 491 },
    { "铜盘擦得发亮","铜匠巷 摩洛哥 晴","11-08", "摩洛哥",
      "铜盘挂满整面墙 锤痕一圈圈 师傅的围裙满是烫洞 手指厚得像铜的", 492 },
    { "从上往下看全蓝了","蓝城屋顶 摩洛哥 晴","11-10", "摩洛哥",
      "从露台往下看 蓝房子一片连一片 天台晒着毯子 猫在瓦上 走房檐", 493 },
    { "墙把林子圈住","棕榈林 摩洛哥 晴","11-12", "摩洛哥",
      "土墙圈住一大片棕榈 渠水从林间穿过 果子挂成串 影子铺了一地", 494 },
    { "塔没修完就停了","哈桑塔 摩洛哥 晴","11-14", "摩洛哥",
      "塔建到一半停了 柱子只立了一半 断柱排成一片 麻雀在柱头开会", 495 },
    { "一格一格像蜂巢","粮仓堡 摩洛哥 晴","11-16", "摩洛哥",
      "粮仓凿成一个个小方格 像放大的蜂巢 梯子搭到顶层 谷粒从缝里漏下来", 496 },
    { "它占着台阶晒太阳","石阶猫 摩洛哥 晴","11-18", "摩洛哥",
      "花猫摊在台阶上 肚皮朝太阳 行人绕着走 它睁一只眼 又闭上", 497 },
    { "面包一炉一炉出","烤炉 摩洛哥 晴","11-20", "摩洛哥",
      "圆面包一炉炉出炉 师傅用长铲一拍 面包弹起来 孩子伸手 接住烫的那个", 498 },
    { "溪水从谷底流过","峡谷 摩洛哥 晴","11-22", "摩洛哥",
      "峡谷夹着一条溪 水声在岩壁间撞 棕榈把影子伸进水里 羊在崖壁上跳", 499 },
    { "水从崖顶掉下来","米尔福德峡湾 新西兰 多云","11-24", "新西兰",
      "瀑布从崖顶一线垂下来 撞在潭里 腾起白雾 彩虹在水雾上 搭了一座", 500 },
    { "圆门开在草坡上","霍比屯 新西兰 晴","11-26", "新西兰",
      "圆门嵌在草坡里 门后是一条小路 篱笆绕成弧 蘑菇长在门柱边", 501 },
    { "羊比草多","牧场 新西兰 晴","11-28", "新西兰",
      "草坡上密密麻麻的羊 白的点 黑的点 牧羊犬一喊 整片坡都在动", 502 },
    { "一棵树站在湖里","瓦纳卡 新西兰 晴","11-30", "新西兰",
      "一棵树孤零零站在水里 影子拖得很长 游客划船过去 绕到它身边拍照", 503 },
    { "冰贴着绿树","冰川 新西兰 多云","12-02", "新西兰",
      "冰舌一直伸到林边 融水在冰下流 蕨类长在岩上 雨林的绿 贴着冰的蓝", 504 },
    { "白汽一直往上冒","地热 新西兰 阴","12-04", "新西兰",
      "地缝里白汽一股股往上冒 地面烫得能煎蛋 硫磺味呛人 步道绕着汽柱", 505 },
    { "风大得吹斜草","海角灯塔 新西兰 多云","12-06", "新西兰",
      "灯塔站在海角尖端 风把草吹成一面倒的旗 浪在礁石上撞碎 塔顶的光转着扫", 506 },
    { "河水是奶白的","冰川河 新西兰 晴","12-08", "新西兰",
      "冰川融水是奶白的 河床铺着细粉 脚踩进去 冰得发麻 沙都没了", 507 },
    { "桥晃在绿水上","吊桥 新西兰 晴","12-10", "新西兰",
      "吊桥踩上去 整座桥直晃 扶手冰凉 桥下的水绿得发暗 石头长满青苔", 508 },
    { "水里还立着一座","库克山 新西兰 晴","12-12", "新西兰",
      "雪山掉进湖里 又立了一遍 云在山顶绕 牧场的牛 抬头看它", 509 },
    { "门楣上全是雕","毛利会堂 新西兰 多云","12-14", "新西兰",
      "门楣雕着螺旋和神面 彩绘还新 走进去 光线暗下来 木雕在阴影里瞪着眼", 510 },
    { "尾巴一甩就不见","观鲸 新西兰 晴","12-16", "新西兰",
      "鲸尾露出海面 一甩 溅起一片水花 又沉回去 只留一圈圈油", 511 },
    { "篙一点船就走","雅芳河 新西兰 晴","12-18", "新西兰",
      "船夫立在船尾 竹篙点一下河底 船贴着岸边的柳 滑进桥洞", 512 },
    { "它守着湖和雪山","好牧羊人教堂 新西兰 晴","12-20", "新西兰",
      "石教堂蹲在湖边的草坡上 窗框着雪山 羊群走到窗前 探头往里看", 513 },
    { "它们挤在礁石上","海豹滩 新西兰 晴","12-22", "新西兰",
      "礁石上叠着一层海豹 有的挠痒 有的打哈欠 最边上那只 差点被挤下去", 514 },
    { "教堂临着湖","蒂卡波 新西兰 晴","12-24", "新西兰",
      "白石教堂蹲在湖边 牧羊犬的铜像立在门口 湖水把教堂泡得发蓝", 515 },
    { "水蓝得发白","普卡基湖 新西兰 晴","12-26", "新西兰",
      "湖面蓝得像兑了牛奶 浪推上来 白得发亮 云掉进去 也染上一层", 516 },
    { "叶子背面是银的","银蕨 新西兰 晴","12-28", "新西兰",
      "银蕨的叶子翻过来 银得发亮 毛利人拿它当路标 月光下 远远就能认", 517 },
    { "不会飞的国鸟","几维鸟 新西兰 晴","12-30", "新西兰",
      "几维鸟躲在阴影里 翅膀退成一小撮 鼻子插进土里 嗅来嗅去 找虫子", 518 },
    { "在水坑里打滚","海豹幼崽 新西兰 晴","01-01", "新西兰",
      "幼崽在潮水坑里打滚 翻过来 又翻过去 妈妈在旁边 眼皮都懒得抬", 519 },
    { "脖子伸得老长","牧场 新西兰 多云","01-03", "新西兰",
      "羊伸长脖子去够篱笆上的叶子 后腿立起来 前蹄搭在木桩 摇摇晃晃", 520 },
    { "从桥上跳下去","蹦极台 新西兰 晴","01-05", "新西兰",
      "蹦极台探在峡谷上方 轮到的人深吸一口气 纵身一跃 绳子反弹时 山谷跟着喊", 521 },
    { "雾从海那头过来","黑沙滩 新西兰 雾","01-07", "新西兰",
      "雾从海面漫上来 先吞掉礁石 再吞掉沙滩 走到雾里 头发挂满水珠", 522 },
    { "木板路绕树走","雨林木道 新西兰 晴","01-09", "新西兰",
      "木板路绕着一棵古树转了个弯 树根把木板顶得鼓起来 告示牌写着 请勿停留", 523 },
    { "泥咕嘟咕嘟冒","地热泥池 新西兰 阴","01-11", "新西兰",
      "泥浆咕嘟咕嘟冒泡 泥点溅在边上 结成一层硬壳 戳个洞 又涌上来", 524 },
    { "船在湖火山在岸","湖镇 新西兰 晴","01-13", "新西兰",
      "湖这头泊着游船 对岸的火山戴着雪帽 汽笛一响 山也跟着回了一声", 525 },
    { "牛排在路口等","农场门 新西兰 晴","01-15", "新西兰",
      "两头牛站在路口 占了半个车道 车停下来 它们不慌不忙 过了马路", 526 },
    { "石头看得清清楚楚","蓝泉 新西兰 晴","01-17", "新西兰",
      "泉水清得能数清河床的石头 一根根水草顺着流摆 泉眼在深处 蓝得发暗", 527 },
    { "浪打石拱","wild海滩 新西兰 多云","01-19", "新西兰",
      "浪撞上石拱 炸开一朵白花 拱里灌满风 呜咽一声 又退回去", 528 },
    { "一行一行的绿","葡萄园 新西兰 晴","01-21", "新西兰",
      "葡萄一行行排在坡上 尽头接着海 风从海上过来 叶子一齐翻背", 529 },
    { "水池那头全是白","泰姬陵 印度 晴","01-23", "印度",
      "白玉的陵立在水池那头 倒影泡在水里 走到池边 脚步不自觉地放轻", 530 },
    { "它在河边站着","泰姬陵 印度 晴","01-25", "印度",
      "白身金顶的陵立在河崖上 亚穆纳河从脚下淌 船夫撑着船 从它面前过", 531 },
    { "墙上全是小窗","风之宫 印度 晴","01-27", "印度",
      "粉色的墙开满小窗 九百多个 蜂巢一样 风从窗里穿过去 整面墙在呼吸", 532 },
    { "房子全刷成蓝的","焦特布尔 印度 晴","01-31", "印度",
      "房子沿着山坡一路刷成蓝的 蓝到城墙根 晒衣的被子搭在蓝墙上 像云落下来", 533 },
    { "伞一顶挨一顶","恒河台阶 印度 晴","02-02", "印度",
      "台阶一层层伸进河里 彩色的伞一把接一把 伞下的人搓着衣服 棒槌敲在石阶上", 534 },
    { "桨轻轻划开水","恒河 印度 晴","02-04", "印度",
      "船桨划开晨雾 水面裂成两半 又合上 灯花的倒影 晃成一串", 535 },
    { "门楼上有小亭","红堡 印度 晴","02-06", "印度",
      "红砂岩的城门顶着一座白亭 象守着门 城门洞深得望不到头", 536 },
    { "塔身一层层刻花","古塔 印度 晴","02-08", "印度",
      "石塔一层层收上去 每层刻满神像和藤蔓 走到塔根 仰头 帽子掉了", 537 },
    { "船屋滑进椰林","回水船屋 印度 晴","02-10", "印度",
      "船屋拐进椰林间的水道 桨声惊起一群白鹭 屋顶上 晒着渔网和椰壳", 538 },
    { "堡是从沙里长出来的","金城 印度 晴","02-12", "印度",
      "金城从沙丘里冒出来 城墙是黄的 塔也是黄的 日出时 整座堡在发光", 539 },
    { "椰子树倒着长","果阿 印度 晴","02-14", "印度",
      "椰子树把影子投进水里 鱼在树影里游 分不清 是树倒着长 还是天翻了", 540 },
    { "门对着大海","孟买 印度 晴","02-16", "印度",
      "石坊大门朝着大海立着 海浪在它脚下排队 鸽子落在拱顶 出租车从门下过", 541 },
    { "小火车慢慢爬坡","大吉岭 印度 晴","02-18", "印度",
      "小火车哼哧哼哧往上爬 烟冒得比车还高 轨道拧成麻花 茶园在窗外翻页", 542 },
    { "茶垄绿到雾里","茶园 印度 雾","02-20", "印度",
      "茶垄一排排绿到雾里 采茶女的头巾在雾中时隐时现 竹篓满了 倒在车上", 543 },
    { "石头刻成了花","泰姬陵 印度 晴","02-22", "印度",
      "大理石上刻出立体的花 一朵朵从墙里开出来 光线移动时 花瓣跟着转身", 544 },
    { "树下挂着经幡","菩提树 印度 晴","02-24", "印度",
      "菩提树的枝干挂满经幡 布条在风里翻 树根把石栏包住 静坐的人 坐在树影里", 545 },
    { "金顶泡在水里","金庙 印度 晴","02-26", "印度",
      "金顶泡在水池里 又亮了一遍 夜里的灯把水池点着 脚步声在回廊里绕", 546 },
    { "水渠从院子中间过","红堡 印度 晴","02-28", "印度",
      "水渠从院子正中间穿过 泉水凉得刺骨 宫殿围着渠建 窗子都朝着水开", 547 },
    { "宫殿漂在湖心","乌代普尔 印度 晴","03-02", "印度",
      "白的宫殿浮在湖心 船是唯一的路 窗子映在水里 一整座城 颠倒着又建了一遍", 548 },
    { "小山一座接一座","香料摊 印度 晴","03-04", "印度",
      "香料堆成一座座小山 辣椒红 姜黄黄 秤梢一翘 塑料袋鼓起来", 549 },
    { "车夫慢慢蹬","巴扎 印度 晴","03-06", "印度",
      "三轮车夫慢慢地蹬着 车铃按得清脆 后视镜上挂着塑料花 车斗里堆着洋葱", 550 },
    { "铃铛系在脚上","舞者 印度 晴","03-08", "印度",
      "脚踝上系满铃铛 一跺脚 铃声炸开 裙摆转起来 铜片在腰上哗哗响", 551 },
    { "他坐得像石头","河畔冥想 印度 晴","03-10", "印度",
      "他坐得跟石头一样 胡子白了 嘴唇还在动 恒河的水 从他面前不回头", 552 },
    { "背上驮着小亭子","大象 印度 晴","03-12", "印度",
      "大象背上驮着描金的亭子 象夫坐在象脖子上 一扇耳朵慢慢地扇 驱赶苍蝇", 553 },
    { "头顶顶着铜罐","阶梯井 印度 晴","03-14", "印度",
      "女人头顶着铜罐 沿台阶一级级走下去 罐里的水 一滴都没洒", 554 },
    { "芒果堆成小山","水果车 印度 晴","03-16", "印度",
      "芒果码得整整齐齐 一筐挨一筐 小贩用荷叶折成碗 挖一勺 递过来", 555 },
    { "猴子占着穹顶","猴庙 印度 晴","03-18", "印度",
      "猴子蹲在穹顶上 一排排 顺着檐角坐 小猴抓着母猴的背 晾太阳", 556 },
    { "台阶一层咬一层","阶梯井 印度 晴","03-20", "印度",
      "台阶一层咬着一层 一直旋到井底 越往下越凉 光从井口 缩成一枚硬币", 557 },
    { "它站在堡墙上开屏","孔雀 印度 晴","03-22", "印度",
      "孔雀在堡墙上开屏 尾羽上的眼斑一只只睁开 尾巴一颤 整面屏都在抖", 558 },
    /* ★2026-10-26 R74（用户令：远行片不混近郊池，采用"规范做法"）：
       下面 4 张原本错落在近郊段（旧下标 279/280/282/297），现统一挪到表尾 582..585。
       ⚠ 下标已变 ⇒ post_load 里有一次性位图置换迁移（post_rev=2），别删。 */
    { "水波晃着房子","运河 意大利威尼斯 晴","11-01", "威尼斯",
      "水波把房子晃成一道一道 船夫唱着曲慢慢摇 桥下的光阴晃悠悠就过去了", 28 },
    { "雪里的红门","鸟居 日本京都 大雪","11-02", "京都",
      "红色的门框住一整个雪白的世界 雪一片一片落下来 落在肩上 也落进心里", 29 },
    { "案上的茶壶","茶壶 日本京都 晴","11-05", "京都",
      "茶壶搁在案上 壶身圆鼓鼓的 壶嘴微微翘 泡开的茶叶 在里头慢慢舒展开", 31 },
    { "屏风上的竹","屏风 日本京都 晴","11-20", "京都",
      "屏风上画着两竿竹 一笔一笔落下去 屋里没什么风 竹叶却像在动", 46 },
};

_Static_assert(sizeof(g_posts) / sizeof(g_posts[0]) == N_POST, "N_POST != g_posts 表项数");

/* ── 模块专属状态（原 static 变量/表）── */

static bool s_myp_warned      = false; /* 190 区已预警过（删卡掉出 190 后复位 → 可再预警）*/

static int         s_sd_fp_idx = -1; /* s_sd_fp 对应的 s_sd[] 下标；-1 = 无 */

static uint8_t s_mp_unrd[MYPOST_MAX / 8 + 1];

static bool    s_mp_unrd_loaded = false;

static page_t   s_post_back     = PG_FUNC;

EXT_RAM_BSS_ATTR uint16_t s_post_arr[N_POST];    /* 到达日序（0 = 无记录） */

/* ★2026-10-26 修 A12：API「活」明信片专用槽（下标 = API_POST_IDX = N_POST）的到达日单独存。
   不把 s_post_arr 开到 N_POST+1 —— NVS blob "post_arr" 长度一变，新旧固件互读会判长度不符
   而把**整张到达日表清零**；API 片本来也是"本次开机才有内容"，单独一个 2B 键最省事。 */
static uint16_t s_api_arr;

/* ★R184：显示序缓存的失效口（定义在后面 post_order 之前）。
   凡是改 g_post_got / g_post_rd / g_post_cat / 到达日的地方都要调它。 */
static void post_order_invalidate(void);

/* ══════════════════════════════════════════════════════════════════════════
 * ★★★ 2026-11-10 用户令：**邮政等级**（特快 / 普快 / 慢递）
 *   起因：用户实机报「正面紫藤架 上海 春，背面却写嘉定，对不上」，确认背面那格是
 *   「寄件来源（邮局）」后，接着要「都是邮局嘛，加几档：特快、普快、再来一个，
 *   让机制更丰富，不要固定文本」。
 *   三档不是贴纸，各自改变投递行为（详见 post_mail_cls_roll / post_slow_tick）：
 *     · 特快 —— 这张**不占本趟预算**（等于白送一张），到达即时；
 *     · 普快 —— 现状（20/50/80% 节点、每趟 ≤3、积压惩罚等一律不动）；
 *     · 慢递 —— 当场**不进信箱**，压 2 天投「在途」队列，到期才投放，
 *               到达额外 +1 亲密（等得值）。队列掉电不丢（NVS）。
 *   等级按片存（s_post_cls[i]），老档缺 blob = 全 0 = 普快，行为与升级前一致。
 * ══════════════════════════════════════════════════════════════════════════ */
EXT_RAM_BSS_ATTR uint8_t s_post_cls[N_POST];     /* 0=普快 1=特快 2=慢递（缺档 = 全 0）*/
#define POST_CLS_STD    0
#define POST_CLS_EXP    1
#define POST_CLS_SLOW   2
#define POST_SLOW_MAX   3       /* 在途队列上限（慢递 15%、POST_SLOW_DELAY 天窗口，3 条足够）*/
/* POST_SLOW_DELAY（压几天）已提到 post_system.h —— 入队侧 loot/exp 与本文件共用同一真源 */
/* 打包：due_day 放高位、片号放低 10 位（N_POST=586 < 1024）*/
#define POST_SLOW_PACK(idx, due) (((int32_t)(due) << 10) | (int32_t)(idx))
#define POST_SLOW_IDX(v)         ((int)((v) & 0x3FF))
#define POST_SLOW_DUE(v)         ((int)((v) >> 10))



void mypost_clock_set(uint32_t now_local) { if (now_local) s_mp_now = now_local; }

/* 算 mypost 区偏移；分区够大才 true */
bool mypost_layout(void)
{
    const esp_partition_t *p = assets_part();
    if (!p) return false;
    if (p->size <= MYPOST_SIZE + 0x10000u) return false;   /* 至少给内置留 64KB */
    s_mp_off = p->size - MYPOST_SIZE;
    return true;
}

/* 读槽元数据 → 有效? + ts（无效/损坏返回 false）*/
static bool mypost_slot_get(int k, uint32_t *ts)
{
    uint8_t meta[16];
    if (!assets_read(s_mp_off + MYPOST_SLOT_OFF + (uint32_t)k * MYPOST_SLOT_SZ + MYPOST_META_OFF,
                     meta, sizeof(meta)))
        return false;
    if (a_rd32(meta) != MYPOST_SLOT_MAGIC) return false;
    if (ts) *ts = a_rd32(meta + 4);
    return true;
}

/* 开机装载：算偏移 + 校验/初始化 header + 扫描槽建索引。非致命。 */
void mypost_load(void)
{
    if (!s_mp_mux) s_mp_mux = xSemaphoreCreateMutex();   /* ★R119：开机单任务创建 */
    if (!mypost_layout()) { ESP_LOGW(TAG, "mypost: 分区过小/缺失，功能禁用"); return; }

    uint8_t hdr[16] = {0};
    bool inited = assets_read(s_mp_off + MYPOST_HDR_OFF, hdr, sizeof(hdr)) &&
                  a_rd32(hdr) == MYPOST_MAGIC;
    if (!inited) {
        /* 首次使用/损坏：擦 header 扇区 → 写 magic/ver（数据槽保持擦除态=全空）*/
        if (!assets_erase(s_mp_off + MYPOST_HDR_OFF, 0x1000)) {
            ESP_LOGW(TAG, "mypost: 擦 header 失败，功能禁用"); return;
        }
        uint8_t w[16] = {0};
        w[0]=(uint8_t)MYPOST_MAGIC;       w[1]=(uint8_t)(MYPOST_MAGIC>>8);
        w[2]=(uint8_t)(MYPOST_MAGIC>>16); w[3]=(uint8_t)(MYPOST_MAGIC>>24);
        w[4]=(uint8_t)MYPOST_VER;         w[5]=(uint8_t)(MYPOST_VER>>8);
        w[6]=(uint8_t)(MYPOST_VER>>16);   w[7]=(uint8_t)(MYPOST_VER>>24);
        if (!assets_write(s_mp_off + MYPOST_HDR_OFF, w, sizeof(w))) {
            ESP_LOGW(TAG, "mypost: 写 header 失败，功能禁用"); return;
        }
        ESP_LOGI(TAG, "mypost: 首次初始化（%u B @ assets+0x%X）", MYPOST_SIZE, (unsigned)s_mp_off);
    }
    /* ★★★ 2026-10-22 扩容 99→200 槽的**免迁移**原理（实测证实，改动前务必读懂）：
       旧区 = [尾-400K, 尾)，新区 = [尾-804K, 尾) —— 旧区整体位于新区**后半段**，
       二者都 4KB 对齐 ⇒ 旧槽 k 的起点 = 尾-400K+4K+k×4K，恰好落在新区槽 (k+101) 的起点上
       （0x34D000 − 0x2E8000 = 404KB = 101 槽）。**老卡数据自动在位，一张不少**
       —— 实测：触屏版升级后日志「已存 1/200」，卡照常能看。
       ⚠ 因此**不要**写"旧槽→新槽"的搬运代码：那会把同一张卡复制成两张。
       ⚠ 旧区 header（= 新区槽 100 的起点偏移 0）残留的 MYPOST_MAGIC 不会被当卡片
          （槽有效判据看的是 meta 偏移 2560 处的 "MYPC"），且将来写卡前会整槽 erase。 */
    int cnt = 0;
    for (int k = 0; k < MYPOST_MAX; ++k) {
        uint32_t ts = 0;
        if (mypost_slot_get(k, &ts)) { s_mp_ts[k] = ts; cnt++; }
        else s_mp_ts[k] = 0;
    }
    s_mp_ready = true;
    ESP_LOGI(TAG, "mypost: 就绪 · 已存 %d/%d · 区 @ assets+0x%X", cnt, MYPOST_MAX, (unsigned)s_mp_off);
}

/* ★2026-10-26 方案第 4 步：`mypost_migrate_slots` 全工程零调用 → 删除。
   它本来就是为了「旧卡槽搬到新槽」，但实测旧区整体落在新区后半段（槽 k → 槽 k+101），
   老卡数据自动在位，再搬一次反而会把同一张卡复制成两张（见 mypost_init 上方注释）。
   ⇒ 这个函数不只是没用，是**不该用**。 */

int mypost_count(void)
{
    int c = 0;
    for (int k = 0; k < MYPOST_MAX; ++k) if (s_mp_ts[k]) c++;
    return c;
}

/* ★R119 修（真根因）：原实现把**传输格式**（0xFF 哨兵 + 变长字段）原样 fwrite 到卡上，
   而回读（mypost_read_text / mypost_read_field / mypost_read_sender）一律按**内置槽紧凑布局**
   取固定偏移（[2268]=tl · [2269]=文字 · [2449]=字段块 · [2520]=发送者）⇒ 卡上旧信：
   文字恒空（2268 读到的是 0xFF）、标题/地址/发送者全部错位。
   现在落卡时就直接按内置槽布局写，读写口径统一。 */
static bool mypost_store_sd(const uint8_t *photo,
                            uint32_t tl, const uint8_t *text,
                            uint32_t tal, const uint8_t *title,
                            uint32_t aal, const uint8_t *addr,
                            uint32_t sl, const uint8_t *sender)
{
    char dir[64];
    snprintf(dir, sizeof(dir), "%s/mypost", ota_sd_mount_point());
    mkdir(dir, 0777);                              /* 已存在 = EEXIST，无视 */
    uint32_t ts = s_mp_now ? s_mp_now : (uint32_t)time(NULL);
    char path[96];
    bool found = false;
    for (int i = 0; i < 4096; ++i) {
        struct stat st;
        snprintf(path, sizeof(path), "%s/%08u.bin", dir, (unsigned)(ts + (uint32_t)i));
        if (stat(path, &st) != 0) { found = true; break; }   /* 找到空位 */
    }
    /* ★R216 全量检查：跑满 4096 次没找到空位时 path 停在最后一个已存在文件，fopen("wb") 会覆盖旧卡信 */
    if (!found) { ESP_LOGE(TAG, "mypost: 4096 个文件名全被占用，放弃写入"); return false; }
    FILE *f = fopen(path, "wb");
    if (!f) { ESP_LOGE(TAG, "mypost: 建不了 %s", path); return false; }
    uint8_t zero[32] = {0};
    bool ok = (fwrite(photo, 1, MYPOST_DATA_BYTES, f) == MYPOST_DATA_BYTES);
    const uint8_t l0 = (uint8_t)tl;
    if (ok) ok = (fwrite(&l0, 1, 1, f) == 1);
    if (ok && tl) ok = (fwrite(text, 1, tl, f) == tl);
    long pos = (long)(MYPOST_DATA_BYTES + 1u + tl);
    while (ok && pos < (long)MYPOST_TITLE_OFF) {   /* 文字后面补齐到字段块起点 */
        uint32_t n = (uint32_t)((long)MYPOST_TITLE_OFF - pos);
        if (n > sizeof(zero)) n = (uint32_t)sizeof(zero);
        ok = (fwrite(zero, 1, n, f) == n);
        pos += (long)n;
    }
    {
        uint8_t blk[MYPOST_FIELD_BLK];
        memset(blk, 0, sizeof(blk));
        if (tal) { blk[0] = (uint8_t)tal; memcpy(blk + 1, title, tal); }
        if (aal) {
            blk[1 + MYPOST_TITLE_MAX] = (uint8_t)aal;
            memcpy(blk + 2 + MYPOST_TITLE_MAX, addr, aal);
        }
        if (ok) ok = (fwrite(blk, 1, sizeof(blk), f) == sizeof(blk));
    }
    pos = (long)MYPOST_TITLE_OFF + (long)MYPOST_FIELD_BLK;
    while (ok && pos < (long)MYPOST_SENDER_OFF) {   /* 补齐到发送者块 */
        uint32_t n = (uint32_t)((long)MYPOST_SENDER_OFF - pos);
        if (n > sizeof(zero)) n = (uint32_t)sizeof(zero);
        ok = (fwrite(zero, 1, n, f) == n);
        pos += (long)n;
    }
    {
        uint8_t sb[1 + MYPOST_SENDER_MAX];
        memset(sb, 0, sizeof(sb));
        if (sl) { sb[0] = (uint8_t)sl; memcpy(sb + 1, sender, sl); }
        if (ok) ok = (fwrite(sb, 1, sizeof(sb), f) == sizeof(sb));
    }
    if (fclose(f) != 0) ok = false;                /* fclose 落盘，失败也算没写成 */
    if (!ok) { ESP_LOGE(TAG, "mypost: 写 %s 失败", path); remove(path); return false; }
    ESP_LOGI(TAG, "mypost: 转存 TF卡 %s（紧凑布局 %u B）", path,
             (unsigned)(MYPOST_SENDER_OFF + 1u + MYPOST_SENDER_MAX));
    return true;
}

/* 关闭当前卡信流并卸卡（引用计数平衡；幂等，可反复调）。 */
void mypost_sd_close(void)
{
    if (s_sd_fp) { fclose(s_sd_fp); s_sd_fp = NULL; }
    if (s_sd_fp_idx >= 0) { ota_sd_unmount(); s_sd_fp_idx = -1; }
}

/* 进「特殊信件」时扫一次卡目录，建 ts 表；无卡/无目录 → s_sd_n=0。 */
void mypost_sd_scan(void)
{
    mypost_sd_close();                /* 进页先卸掉上一轮残留流，引用计数归位 */
    s_sd_n = 0;
    /* ★R212 修（全量审计）：扫不到任何卡信时（没卡 / 拔卡 / 文件被外部删掉）
       必须把「卡信未读」全局标志清掉 —— 否则特殊信件红点与首页邮件角标永久 +1，
       而且没有任何条目能点开清除。 */
    if (!ota_sd_ready()) { loot_nvs_set_i32("mp_sd_unrd", 0); return; }
    if (!ota_sd_mount()) { loot_nvs_set_i32("mp_sd_unrd", 0); return; }
    char dir[64];
    snprintf(dir, sizeof(dir), "%s/mypost", ota_sd_mount_point());
    DIR *d = opendir(dir);
    if (d) {
        struct dirent *e;
        while ((e = readdir(d)) && s_sd_n < MYPOST_SD_MAX) {
            const char *nm = e->d_name;
            const size_t nl = strlen(nm);
            if (nl < 4 || strcmp(nm + nl - 4, ".bin") != 0) continue;
            uint32_t ts = 0;                    /* 文件名 = 十进制 ts（与内置槽 ts 同口径 → 可直接并序）*/
            for (size_t i = 0; i + 4 < nl; ++i) {
                if (nm[i] < '0' || nm[i] > '9') { ts = 0; break; }
                ts = ts * 10u + (uint32_t)(nm[i] - '0');
            }
            if (!ts) continue;                  /* 文件名不是纯数字 → 不是我们写的转存件，跳过
                                                   （否则 cnt 会多算一条、并序时位次对不上）*/
            s_sd[s_sd_n++] = ts;
        }
        closedir(d);
    }
    if (s_sd_n == 0) loot_nvs_set_i32("mp_sd_unrd", 0);   /* ★R212：目录空也要清未读 */
    ota_sd_unmount();
}

/* 打开第 idx 张卡信并保持流（同 idx 已开则复用）；返回 0=OK / -1=失败。 */
static int mypost_sd_open(int idx)
{
    if (idx < 0 || idx >= s_sd_n) return -1;
    if (s_sd_fp_idx == idx && s_sd_fp) return 0;
    mypost_sd_close();
    if (!ota_sd_mount()) return -1;
    char path[64];
    /* ★R212 修（全量审计）：写入用 `%08u.bin`，读/删却用 `%u.bin` ——
       未校时（ts 很小）时同一张卡两个路径不一致 ⇒ 重启后列表里有、读出来全空、删不掉。
       三处统一成 `%08u.bin`（ts 已是 10 位时两种写法等价）。 */
    snprintf(path, sizeof(path), "%s/mypost/%08u.bin", ota_sd_mount_point(), (unsigned)s_sd[idx]);
    s_sd_fp = fopen(path, "rb");
    if (!s_sd_fp) { ota_sd_unmount(); return -1; }
    s_sd_fp_idx = idx;
    return 0;
}

/* 从当前打开的卡信读 [off, off+len) 到 dst。需先 mypost_sd_open(idx)。 */
static bool mypost_sd_read(int idx, uint32_t off, uint32_t len, uint8_t *dst)
{
    if (!dst || mypost_sd_open(idx) != 0) return false;
    if (fseek(s_sd_fp, (long)off, SEEK_SET) != 0) return false;
    return fread(dst, 1, len, s_sd_fp) == len;
}

/* 删除卡信：unlink 文件 + 从 s_sd[] 摘除（后续 mypost_slots 自动重排）。 */
bool mypost_sd_del(int idx)
{
    if (idx < 0 || idx >= s_sd_n) return false;
    char path[64];
    snprintf(path, sizeof(path), "%s/mypost/%08u.bin", ota_sd_mount_point(), (unsigned)s_sd[idx]);
    if (s_sd_fp_idx == idx) mypost_sd_close();   /* 删的是当前打开的 → 先卸流（引用计数归位）*/
    if (!ota_sd_mount()) return false;
    const int r = remove(path);
    ota_sd_unmount();
    if (r != 0) return false;
    for (int i = idx; i + 1 < s_sd_n; ++i) s_sd[i] = s_sd[i + 1];
    --s_sd_n;
    return true;
}

static void mypost_unrd_load(void)
{
    if (s_mp_unrd_loaded) return;
    memset(s_mp_unrd, 0, sizeof(s_mp_unrd));
    (void)loot_nvs_get_blob("mp_unrd", s_mp_unrd, sizeof(s_mp_unrd));
    s_mp_unrd_loaded = true;
}

bool mypost_entry_unread(int e)
{
    /* ★R153（全量检阅 P1-3）：R147 起卡信编码 e=-2-i 也是**合法条目**，
       旧的 `e < 0` 把全部卡信挡掉 ⇒ 特殊信件列表的红点永远不画（main.c:13213）。
       卡信没有稳定槽号，未读本来就走 mp_sd_unrd 的 0/1 全局标志
       （置 1：post_system.c:1601 转存 TF卡；清 0：mypost_open_sel / mypost_del；
        首页角标也是读它，post_system.c:1528）。这里沿用同一份标志，不新造位图。
       ⚠ 语义限制：0/1 标志无法区分「哪一张」卡信未读，故列表里每张卡信都会亮红点，
       进任一详情后一起清 —— 与现有首页角标口径一致。
       -1 才是「取不到条目」哨兵（R147），保持 false。 */
    if (e == -1) return false;
    if (e < -1) return loot_nvs_i32("mp_sd_unrd", 0) != 0;
    if (e >= MYPOST_MAX) return false;
    mypost_unrd_load();
    return (s_mp_unrd[e >> 3] >> (e & 7)) & 1;
}

void mypost_unrd_set(int e, bool v)
{
    if (e < 0 || e >= MYPOST_MAX) return;
    mypost_unrd_load();
    const uint8_t m = (uint8_t)(1u << (e & 7));
    const bool cur = (s_mp_unrd[e >> 3] & m) != 0;
    if (cur == v) return;
    if (v) s_mp_unrd[e >> 3] |= m;
    else   s_mp_unrd[e >> 3] &= (uint8_t)~m;
    loot_nvs_set_blob("mp_unrd", s_mp_unrd, sizeof(s_mp_unrd));
    ESP_LOGI(TAG, "mypost: 未读位 %d → %d", e, (int)v);
}

/* 动态信箱未读数（内置 200 槽 + 满仓后转存 TF卡的 0/1 个“有未读卡信”标志） */
int mypost_unread(void)
{
    mypost_unrd_load();
    int n = 0;
    for (int k = 0; k < MYPOST_MAX; ++k)
        if (s_mp_ts[k] && mypost_entry_unread(k)) n++;
    if (loot_nvs_i32("mp_sd_unrd", 0) != 0) n++;
    return n;
}

static int mypost_add_body(const uint8_t *data, uint32_t len);

/* ★R119：落箱入口统一加锁（调用方可能是任意任务）。 */
int mypost_add(const uint8_t *data, uint32_t len)
{
    if (!s_mp_mux) s_mp_mux = xSemaphoreCreateMutex();
    if (!s_mp_mux) return mypost_add_body(data, len);   /* 极端：建锁失败 → 退化为无锁 */
    xSemaphoreTake(s_mp_mux, portMAX_DELAY);
    const int r = mypost_add_body(data, len);
    xSemaphoreGive(s_mp_mux);
    return r;
}

static int mypost_add_body(const uint8_t *data, uint32_t len)
{
    if (!s_mp_ready || !data) return -1;
    bool evicted = false;                                 /* ★2026-10-22：本张是否顶掉别人才存进来 */
    /* 长度校验三种：2268 纯图 / 2269+tl 旧文字格式 / ★2026-10-22 0xFF 哨兵新格式
       （图 + 文字 + 标题 + 地址）。哨兵 0xFF 与旧格式不冲突（旧 tl ≤ 180 < 255）。 */
    uint32_t tl = 0, tal = 0, aal = 0, sl = 0;
    const uint8_t *title = NULL, *addr = NULL, *text = NULL, *sender = NULL;
    if (len == MYPOST_DATA_BYTES) {
        tl = 0;                                             /* 旧版纯图 */
    } else if (len > MYPOST_TEXT_OFF && len <= MYPOST_PAYLOAD_MAX &&
               data[MYPOST_LEN_OFF] == 0xFFu) {
        /* ★2026-10-22 修（真根因）：网页布局 = [2268]=0xFF · [2269]=tl ·
           [2270..2270+tl)=背面文字 · [2270+tl]=tal · 标题 · [..]=aal · 地址。
           原解析读完 tl 后**没跳过 tl 个文字字节**，直接把文字首字节当 tal 读
           ⇒ 只要填了背面文字就必被判非法（mypost_add 返回 -1，网页显示"满了"）。 */
        uint32_t o = MYPOST_TEXT_OFF;                       /* 2269 = tl */
        if (o >= len) return -1;
        tl = data[o++];                                     /* 2269 → o=2270 */
        if (tl > MYPOST_TEXT_MAX || o + tl > len) return -1;
        text = data + o;                                    /* 2270 = 文字起点 */
        o += tl;
        if (o >= len) return -1;
        tal = data[o++];
        if (tal > MYPOST_TITLE_MAX || o + tal > len) return -1;
        title = data + o; o += tal;
        if (o >= len) return -1;
        aal = data[o++];
        if (aal > MYPOST_ADDR_MAX || o + aal > len) return -1;
        addr = data + o; o += aal;
        /* ★2026-10-27 用户令：可选 [sl][sender] —— 转发来的卡带发送者（好友名）；
           其它来源（网页/API）没有这一段。**原标题不再被覆盖**，发送者单独存。 */
        if (o < len) {
            sl = data[o++];
            if (sl > MYPOST_SENDER_MAX || o + sl > len) return -1;
            sender = data + o; o += sl;
        }
        if (o != len) return -1;                            /* 尾部多余字节 = 拒收 */
    } else if (len > MYPOST_TEXT_OFF && len <= MYPOST_TEXT_OFF + MYPOST_TEXT_MAX) {
        tl = data[MYPOST_LEN_OFF];
        if (tl == 0 || tl != len - MYPOST_TEXT_OFF || tl > MYPOST_TEXT_MAX) return -1;
        text = data + MYPOST_TEXT_OFF;                      /* 旧格式：文字紧跟 tl */
    } else {
        return -1;
    }
    int k = -1;
    for (int i = 0; i < MYPOST_MAX; ++i) if (!s_mp_ts[i]) { k = i; break; }
    if (k < 0) {
        /* ★★ 2026-10-22 用户令：**满 200 张不再拒收**。
           ★2026-10-22 TF 接线：**有卡 → 转存 TF卡**（/sdcard/mypost/，不动内置 200 张，
           提示页出 C 态）；无卡（或写卡失败）→ 顶掉最旧的一张（提示页出 B 态）。 */
        if (ota_sd_mount()) {
            if (mypost_store_sd(data, tl, text, tal, title, aal, addr, sl, sender)) {
                ota_sd_unmount();
                s_myp_notice = 3;                  /* C 态：转存 TF卡告知 */
                /* ★2026-10-23：卡信也点亮未读（没有稳定槽号 → 单独一个标志位） */
                loot_nvs_set_i32("mp_sd_unrd", 1);
                ESP_LOGI(TAG, "★ mypost 已满 %d 张 → 有卡，转存 TF卡（内置没动）", MYPOST_MAX);
                return MYPOST_MAX;                 /* ≥0 = 存入成功（net_prov 回 "OK"）*/
            }
            ota_sd_unmount();                      /* 写卡失败 → 落回顶掉路径 */
            ESP_LOGW(TAG, "★ 转存 TF卡失败 → 落回顶掉最旧的一张");
        }
        /* 顶掉最旧的一张 —— 一视同仁：API 卡 / 预制卡 / 混着都一样，按**时间戳最小**挑
           （不是槽号最小，槽号是复用顺序，跟新旧无关）。置一次提示标志，列表页显示、看过即清。 */
        uint32_t ots = 0xFFFFFFFFu;
        int oldest = -1;
        for (int i = 0; i < MYPOST_MAX; ++i)
            if (s_mp_ts[i] && s_mp_ts[i] < ots) { ots = s_mp_ts[i]; oldest = i; }
        if (oldest < 0) return -1;                          /* 理论上不会发生（满则必有有效槽）*/
        k = oldest;
        evicted        = true;
        ESP_LOGW(TAG, "★ mypost 已满 %d 张 → 顶掉最旧的一张（槽 %d，ts=%u）", MYPOST_MAX, k, (unsigned)ots);
    }
    const uint32_t base = s_mp_off + MYPOST_SLOT_OFF + (uint32_t)k * MYPOST_SLOT_SZ;
    if (!assets_erase(base, MYPOST_SLOT_SZ)) return -1;
    if (!assets_write(base, data, MYPOST_DATA_BYTES)) return -1;
    const uint8_t l0 = (uint8_t)tl;
    if (!assets_write(base + MYPOST_LEN_OFF, &l0, 1)) return -1;
    if (tl && text && !assets_write(base + MYPOST_TEXT_OFF, text, tl)) return -1;
    /* ★2026-10-22 字段块**恒写**（无标题/地址 = 全 0）—— 槽擦除态是 0xFF，不写会把
       残留 0xFF 当字段长度读出垃圾 */
    {
        uint8_t blk[MYPOST_FIELD_BLK] = {0};
        if (tal > 0) { blk[0] = (uint8_t)tal; memcpy(blk + 1, title, tal); }
        if (aal > 0) {
            blk[1 + MYPOST_TITLE_MAX] = (uint8_t)aal;
            memcpy(blk + 2 + MYPOST_TITLE_MAX, addr, aal);
        }
        if (!assets_write(base + MYPOST_TITLE_OFF, blk, sizeof(blk))) return -1;
    }
    {   /* ★2026-10-27：发送者名字单存（空 = 全 0；恒写，避免擦除态 0xFF 被当长度） */
        uint8_t sb[1 + MYPOST_SENDER_MAX] = {0};
        if (sl > 0 && sender) { sb[0] = (uint8_t)sl; memcpy(sb + 1, sender, sl); }
        if (!assets_write(base + MYPOST_SENDER_OFF, sb, sizeof(sb))) return -1;
    }
    /* ★2026-10-22 E 项：ts 改存 now_local（本地伪 epoch；门户会话期间冻结在进菜单时刻，
       分钟级误差可接受）。旧口径 time(NULL) 在 SNTP 前是开机秒 → 日期成 1970。 */
    uint32_t ts = s_mp_now;
    if (ts == 0) ts = (uint32_t)time(NULL);                 /* 兜底：时钟钩子没跑过的极端情况 */
    uint8_t meta[16] = {0};
    meta[0]=(uint8_t)MYPOST_SLOT_MAGIC;      meta[1]=(uint8_t)(MYPOST_SLOT_MAGIC>>8);
    meta[2]=(uint8_t)(MYPOST_SLOT_MAGIC>>16);meta[3]=(uint8_t)(MYPOST_SLOT_MAGIC>>24);
    meta[4]=(uint8_t)ts;                     meta[5]=(uint8_t)(ts>>8);
    meta[6]=(uint8_t)(ts>>16);               meta[7]=(uint8_t)(ts>>24);
    /* ★R189：来源位（0=手机相册 / 1=AI生成），由 mypost_src_hint 在落箱前声明，
       取一次就清（不会串到下一张卡）。 */
    meta[8] = s_mp_src_hint;
    s_mp_src_hint = 0;
    if (!assets_write(base + MYPOST_META_OFF, meta, sizeof(meta))) return -1;
    s_mp_ts[k] = ts;
    /* ★2026-10-23：新卡点亮未读 → 首页明信片角标 + 分类页/列表行红点（用户实机报的 bug） */
    mypost_unrd_set(k, true);
    ESP_LOGI(TAG, "mypost: 存入槽 %d（%d/%d%s）", k, mypost_count(), MYPOST_MAX,
             tl ? " · 含背面文字" : "");
    /* ★★2026-10-22 用户令：存成功后置提示标志（httpd 任务只置标志，UI 交主循环弹页）——
       ① 满 200 有卡转存 → C 态「转存 TF卡」告知（无拒收按钮）；
       ② 满 200 无卡顶掉 → B 态「已顶掉最旧的一张」告知（无拒收按钮，自动顶掉）；
       ③ 首次进 190..199 区 → A 态将满预警一次（**仅无卡时**：有卡满了也只是转存，不丢信；
          删卡掉出 190 后 s_myp_warned 复位，可再预警）。
       顶掉/转存告知优先级更高：同一张卡两者都命中时只弹 2/3。 */
    if (evicted) s_myp_notice = 2;
    {
        const int c = mypost_count();
        if (c >= MYPOST_MAX - 10 && c < MYPOST_MAX) {
            if (!s_myp_warned) {
                /* 探一次卡：有卡就不预警（探完即还引用，不占着卡）*/
                const bool has_card = ota_sd_mount();
                if (has_card) ota_sd_unmount();
                if (!has_card) { s_myp_warned = true; if (!s_myp_notice) s_myp_notice = 1; }
            }
        } else if (c < MYPOST_MAX - 10) {
            s_myp_warned = false;
        }
    }
    return k;
}

bool mypost_del(int e)
{
    if (e >= 0) {
        if (!s_mp_ready || e >= MYPOST_MAX || !s_mp_ts[e]) return false;
        const uint32_t base = s_mp_off + MYPOST_SLOT_OFF + (uint32_t)e * MYPOST_SLOT_SZ;
        if (!assets_erase(base, MYPOST_SLOT_SZ)) return false;
        s_mp_ts[e] = 0;
        mypost_unrd_set(e, false);                 /* ★2026-10-23：删卡清未读位 */
        /* ★2026-10-22：删到 190 以下 → 复位「将满预警」标志，下次再进 190 区会重新预警
           （mypost_add 只管到达；删除在这条路上，两边一起维护标志才不会漏预警/重复预警）*/
        if (mypost_count() < MYPOST_MAX - 10) s_myp_warned = false;
        ESP_LOGI(TAG, "mypost: 删除槽 %d（剩 %d/%d）", e, mypost_count(), MYPOST_MAX);
        return true;
    }
    {
        const bool ok = mypost_sd_del(-2 - e);     /* 卡信：卸卡删文件 */
        if (ok && s_sd_n <= 0) loot_nvs_set_i32("mp_sd_unrd", 0);   /* ★2026-10-23：卡信删空清未读 */
        return ok;
    }
}

static bool mypost_read(int e, uint8_t *dst)
{
    if (!s_mp_ready || !dst) return false;
    if (e >= 0) {
        if (e >= MYPOST_MAX || !s_mp_ts[e]) return false;
        return assets_read(s_mp_off + MYPOST_SLOT_OFF + (uint32_t)e * MYPOST_SLOT_SZ,
                           dst, MYPOST_DATA_BYTES);
    }
    return mypost_sd_read(-2 - e, 0, MYPOST_DATA_BYTES, dst);
}

int mypost_read_text(int e, char *dst, int cap)
{
    if (!s_mp_ready || !dst || cap <= 0) return -1;
    uint8_t l0 = 0;
    if (e >= 0) {
        if (e >= MYPOST_MAX || !s_mp_ts[e]) return -1;
        const uint32_t base = s_mp_off + MYPOST_SLOT_OFF + (uint32_t)e * MYPOST_SLOT_SZ;
        if (!assets_read(base + MYPOST_LEN_OFF, &l0, 1)) return -1;
    } else {
        if (!mypost_sd_read(-2 - e, MYPOST_LEN_OFF, 1, &l0)) return -1;
    }
    if (l0 == 0 || l0 > MYPOST_TEXT_MAX) { dst[0] = 0; return 0; }
    if (l0 >= (uint32_t)cap) l0 = (uint8_t)(cap - 1);
    if (e >= 0) {
        const uint32_t base = s_mp_off + MYPOST_SLOT_OFF + (uint32_t)e * MYPOST_SLOT_SZ;
        if (!assets_read(base + MYPOST_TEXT_OFF, dst, l0)) return -1;
    } else {
        if (!mypost_sd_read(-2 - e, MYPOST_TEXT_OFF, l0, (uint8_t *)dst)) return -1;
    }
    dst[l0] = 0;
    /* ★R189：读卡时按字库再洗一遍（网页上传/好友转发/历史卡没经过生成期清洗）*/
    post_font_fix(dst, cap);
    return l0;
}

static int mypost_read_field(int e, int want_addr, char *dst, int cap)
{
    if (!s_mp_ready || !dst || cap <= 0) return -1;
    uint8_t blk[MYPOST_FIELD_BLK];
    if (e >= 0) {
        if (e >= MYPOST_MAX || !s_mp_ts[e]) return -1;
        const uint32_t base = s_mp_off + MYPOST_SLOT_OFF + (uint32_t)e * MYPOST_SLOT_SZ;
        if (!assets_read(base + MYPOST_TITLE_OFF, blk, sizeof(blk))) return -1;
    } else {
        if (!mypost_sd_read(-2 - e, MYPOST_TITLE_OFF, sizeof(blk), blk)) return -1;
    }
    const uint32_t off = want_addr ? (1u + MYPOST_TITLE_MAX) : 0u;
    const uint32_t lmax = want_addr ? MYPOST_ADDR_MAX : MYPOST_TITLE_MAX;
    uint8_t l = blk[off];
    if (l == 0 || l > lmax) { dst[0] = 0; return 0; }
    if (l >= (uint32_t)cap) l = (uint8_t)(cap - 1);
    memcpy(dst, blk + off + 1, l);
    dst[l] = 0;
    /* ★R189：标题/地址同样按字库清洗（同 mypost_read_text，防方框字）*/
    post_font_fix(dst, cap);
    return l;
}

int mypost_read_title(int k, char *dst, int cap) { return mypost_read_field(k, 0, dst, cap); }

/* ★2026-10-27：转发者名字（列表行尾右对齐显示）。没存过（老卡/自建卡）→ 返回 0。 */
int mypost_read_sender(int k, char *dst, int cap)
{
    if (!dst || cap <= 0) return -1;
    dst[0] = 0;
    uint8_t blk[1 + MYPOST_SENDER_MAX];
    if (k >= 0) {
        if (k >= MYPOST_MAX || !s_mp_ts[k]) return -1;
        const uint32_t base = s_mp_off + MYPOST_SLOT_OFF + (uint32_t)k * MYPOST_SLOT_SZ;
        if (!assets_read(base + MYPOST_SENDER_OFF, blk, sizeof(blk))) return -1;
    } else {
        if (!mypost_sd_read(-2 - k, MYPOST_SENDER_OFF, sizeof(blk), blk)) return -1;
    }
    uint32_t l = blk[0];
    if (l == 0 || l > MYPOST_SENDER_MAX) return 0;
    if (l >= (uint32_t)cap) l = (uint32_t)cap - 1;
    memcpy(dst, blk + 1, l);
    dst[l] = 0;
    return (int)l;
}

static int mypost_read_addr (int k, char *dst, int cap) { return mypost_read_field(k, 1, dst, cap); }

int post_recv_cb(const uint8_t *data, uint32_t len)
{
    if (len != MYPOST_DATA_BYTES && !(len > MYPOST_TEXT_OFF && len <= MYPOST_PAYLOAD_MAX)) return -1;
    return mypost_add(data, len);
}

const post_t *post_at(int i)
{
    if (i < 0 || (i != API_POST_IDX && i >= N_POST)) i = 0;   /* ★2026-10-23 修：判负/越界前置，防 g_posts[-1]/越界读（API 槽 127 除外） */
    return (i == API_POST_IDX) ? &g_api_live : &g_posts[i];
}

/* 详情页「正在看第几张」的下标换算：API 槽不经取模（N_POST 取模会把它卷回 0）。 */
int post_view_i(void)
{
    return (g_post_view == API_POST_IDX) ? API_POST_IDX : (g_post_view % N_POST);
}

void post_arr_set(int i, int day)
{
    if (day <= 0 || day > 60000) return;
    if (i == API_POST_IDX) { s_api_arr = (uint16_t)day; post_order_invalidate(); return; }   /* ★A12：专用槽单独记 */
    if (i < 0 || i >= N_POST) return;
    s_post_arr[i] = (uint16_t)day;
    post_order_invalidate();                       /* ★R184：到达日就是排序键 */
}

/* ══ 邮政等级：读 / 写 / 名字 / 掷骰 ══════════════════════════════════════ */
int post_mail_cls(int i)
{
    /* ★2026-11-10：API「活」槽 = 现场生成的那张（文字模型现编 + 生图），
       语义上就是「现做现寄」→ 恒特快；它也从不入 NVS 等级表（重启即消失）。 */
    if (i == API_POST_IDX) return POST_CLS_EXP;
    if (i < 0 || i >= N_POST) return POST_CLS_STD;
    return (int)s_post_cls[i];
}

void post_mail_cls_set(int i, int c)
{
    if (i < 0 || i >= N_POST) return;
    if (c != POST_CLS_EXP && c != POST_CLS_SLOW) c = POST_CLS_STD;
    s_post_cls[i] = (uint8_t)c;
}

const char *post_mail_cls_name(int c)
{
    switch (c) {
    case POST_CLS_EXP:  return "特快";
    case POST_CLS_SLOW: return "慢递";
    default:            return "普快";
    }
}

/* 掷骰口径：普快 70% / 特快 15% / 慢递 15%。
   三档都必须**落到行为**上（见 trip_post_send / exp_day_mail / post_slow_tick），
   否则就只是换个词 —— 用户原话「不要固定文本单调」。 */
int post_mail_cls_roll(void)
{
    const uint32_t r = esp_random() % 100u;
    if (r < 15) return POST_CLS_EXP;
    if (r < 30) return POST_CLS_SLOW;
    return POST_CLS_STD;
}

/* ── 慢递「在途」队列（NVS: pslow_n + pslow_0..2，打包见 POST_SLOW_PACK）──
   为什么落 NVS：慢递要跨 2 天 + 中间必然深睡/掉电，RAM 队列等于没有。 */
static int post_slow_load(int32_t *q)
{
    nvs_handle_t h;
    int32_t v = 0;
    if (nvs_open("petns", NVS_READONLY, &h) != ESP_OK) return 0;
    if (nvs_get_i32(h, "pslow_n", &v) == ESP_OK) v = v;
    else v = 0;
    if (v < 0) v = 0;
    if (v > POST_SLOW_MAX) v = POST_SLOW_MAX;
    for (int k = 0; k < v; ++k) {
        char key[24];   /* "pslow_%d"：编译器按 int 最坏 10 位算，12B 会被 -Wformat-truncation 拦 */
        snprintf(key, sizeof(key), "pslow_%d", k);
        /* ★2026-11-12 修：缺键/损坏**不能填 0** —— 打包宏把 0 解析成 idx=0、due=0，
           tick 会误把「第 0 张卡」当成慢递到达投出去（还倒发 +3 亲密）。填 -1 显式标坏。 */
        if (nvs_get_i32(h, key, &q[k]) != ESP_OK) q[k] = -1;
    }
    nvs_close(h);
    return (int)v;
}

static void post_slow_store(const int32_t *q, int n)
{
    nvs_handle_t h;
    if (n <= 0) n = 0;
    if (n > POST_SLOW_MAX) n = POST_SLOW_MAX;
    if (nvs_open("petns", NVS_READWRITE, &h) != ESP_OK) return;
    nvs_set_i32(h, "pslow_n", (int32_t)n);
    for (int k = 0; k < n; ++k) {
        char key[24];   /* "pslow_%d"：编译器按 int 最坏 10 位算，12B 会被 -Wformat-truncation 拦 */
        snprintf(key, sizeof(key), "pslow_%d", k);
        nvs_set_i32(h, key, q[k]);
    }
    nvs_commit(h);
    nvs_close(h);
}

bool post_slow_enqueue(int idx, int due_day)
{
    if (idx < 0 || idx >= N_POST || due_day <= 0 || due_day > 60000) return false;
    int32_t q[POST_SLOW_MAX] = { 0 };
    int n = post_slow_load(q);
    /* ★R213（用户令）：队列满 → **拒绝入队**，不再顶掉最旧一条。
       原来静默顶掉的那条多数还没到期（慢递本就按天排队），投递会被彻底跳过且无任何提示，
       玩家只看到「寄出了但永远没到」。调用点拿 false 会降级成当场投（见 exp_system.c 注释）。 */
    if (n >= POST_SLOW_MAX) {
        ESP_LOGW(TAG, "★ 慢递队列已满（%d 条）→ 拒绝入队：「%s」改走当场投递", n, g_posts[idx].title);
        return false;
    }
    q[n++] = POST_SLOW_PACK(idx, due_day);
    post_slow_store(q, n);
    ESP_LOGI(TAG, "★★ 慢递入队：「%s」压到第 %d 天（队列 %d 条）",
             g_posts[idx].title, due_day, n);
    return true;
}

int post_slow_pending(void)
{
    int32_t q[POST_SLOW_MAX] = { 0 };
    return post_slow_load(q);
}

/* ★R231：换片要回写行程流水（jtrip 是 main.c 的静态数据，只能由那边改）——
   定义在 main.c 的 jtrip_trip_posts 之后，两版共用。 */
void jtrip_swap_post(int old_idx, int new_idx);
void jtrip_drop_post(int post_idx);

/* 到期投放。调用点三处：post_load 末尾（开机）、clock_rebase（每次校时）、exp_day_mail 末尾。
   幂等：投完就清队列，同一天重复调用不会重复投。 */
int post_slow_tick(int today)
{
    if (today <= 0) return 0;
    int32_t q[POST_SLOW_MAX] = { 0 };
    const int n = post_slow_load(q);
    if (n <= 0) return 0;
    int32_t keep[POST_SLOW_MAX] = { 0 };
    int32_t pick[POST_SLOW_MAX] = { 0 };        /* 本次要投放的片号 */
    int32_t pick_due[POST_SLOW_MAX] = { 0 };    /* 对应原定到达日（只用于日志） */
    int nk = 0, nd = 0;
    for (int k = 0; k < n; ++k) {
        if (q[k] <= 0) continue;                    /* ★2026-11-12 修：坏条目整条丢弃 */
        const int idx = POST_SLOW_IDX(q[k]);
        const int due = POST_SLOW_DUE(q[k]);
        if (idx < 0 || idx >= N_POST || due <= 0) continue;  /* 坏条目（长度/打包对不上）*/
        if (due > today) { keep[nk++] = q[k]; continue; }
        int a = idx;
        if (post_is_got(a)) {
            /* ★★R229 修（用户令，2026-11-18）：换片**只许同城**。
               用户原话：「哪怕是慢递，它也是去杭州那趟寄的明信片，不该被替换成新疆的；
               而且下一次猫不会再跑一趟杭州，没法补救」。
               原实现 = 在整个近郊池 92 张里随机抽一张没收到过的 ⇒ 地点直接换城，
               行程里写着 A、信箱里到手 B，"根本不在一个地方"。
               新规则：① 同城（city 字段完全一致）且没收到过 → 换；
                       ② 同城也没有了 → **丢弃这一条**（用户选定 B：宁可少一封，绝不重复、
                          绝不跨城）。 */
            const post_t *po   = post_at(idx);
            const char   *city = (po && po->city[0]) ? po->city : NULL;
            a = -1;
            if (city) {
                int cnt = 0;
                for (int t = 0; t < N_POST_BASE; ++t) {
                    if (post_is_got(t)) continue;
                    if (strcmp(g_posts[t].city, city) != 0) continue;
                    ++cnt;                                   /* 蓄水池抽样：均匀取一张 */
                    if ((int)(esp_random() % (unsigned)cnt) == 0) a = t;
                }
            }
            if (a < 0) {
                ESP_LOGW(TAG, "★ 慢递到期：同城「%s」已无新片 → 丢弃这一条（不跨城、不重复）",
                         city ? city : "?");
                /* ★R231（用户令）：舍弃的片**不该留在行程里** —— 把寄出时写的那条流水删掉。 */
                jtrip_drop_post(idx);
                continue;
            }
            ESP_LOGW(TAG, "★ 慢递换片（限同城）：%d → %d（%s）", idx, a, city);
            /* ★R231（用户令）：换出来的片**进同一条流水**（趟号/第几天都不动，只把片号换掉），
               否则行程详情显示的是没到手的原片、跟信箱永远对不上。 */
            jtrip_swap_post(idx, a);
        }
        pick[nd] = a;
        pick_due[nd] = due;
        nd++;
    }
    /* ★R208 修（复查 · 幂等性）：原来「投一张 → post_save()」循环完才 post_slow_store()，
       两步之间断电/复位 ⇒ 队列里那条仍在，下次开机**又投一张新片、再 +3 亲密**（可反复）。
       现在先把"扣掉到期条目"的新队列落盘，再逐张发放 —— 最坏只丢一封，绝不重复。 */
    post_slow_store(keep, nk);
    int delivered = 0;
    for (int k = 0; k < nd; ++k) {
        const int a   = pick[k];
        const int due = pick_due[k];
        post_set_got(a);
        post_arr_set(a, today);                     /* 到达日 = 真正投放日（列表按它降序）*/
        post_mail_cls_set(a, POST_CLS_SLOW);
        post_mark_unread(a);
        post_save();
        /* ★2026-11-12 修（规格见本文件 :1288「到期才投放，到达额外 +1 亲密（等得值）」）：
           慢递入队侧不再提前发亲密，统一在**真正投放这一刻**结 +3 = 基础 2 + 等得值 1。
           队列已在上面清掉（幂等）⇒ 不会重复发放。走自动通道（封顶 70、闲置淡出期间不生效），
           与普通寄片 +2 同口径；写回 RAM 防深睡覆写。 */
        { int ni = ws_intimacy_add_auto(3); if (ni >= 0) g_app.st.intimacy = ni; }
        delivered++;
        ESP_LOGW(TAG, "★★ 慢递到达：「%s」（原定第 %d 天，今第 %d 天）", g_posts[a].title, due, today);
    }
    return delivered;
}

/* ★R74：旧下标 → 新下标（4 张远行片移到表尾 582..585，其余依次前移）。
   由旧/新 g_posts 逐条对账生成并验证：586/586 双射、公式与实测 0 误差。 */
static int post_rev2_map(int o)
{
    if (o == 279) return 582;      /* 威尼斯·水波晃着房子 */
    if (o == 280) return 583;      /* 京都·雪里的红门 */
    if (o == 282) return 584;      /* 京都·案上的茶壶 */
    if (o == 297) return 585;      /* 京都·屏风上的竹 */
    if (o < 279)  return o;
    if (o == 281) return 279;      /* 279/280 已移走 */
    if (o <= 296) return o - 3;    /* 283..296：前面移走 3 张 */
    return o - 4;                   /* 298..585：前面移走 4 张 */
}

void post_load(void)
{
    /* ★2026-10-26 R74：4 张远行片（旧下标 279/280/282/297）移到表尾 582..585，
       近郊池边界 N_POST_BASE 298→294。下标变了 ⇒ 老档三张位图必须按**同一置换**重排一次，
       否则收藏进度会指到别的片。映射由旧/新 g_posts 逐条对账得出（脚本验证 586/586 双射、0 误差）。 */
    static uint8_t s_old_rd[POST_RD_BYTES], s_old_got[POST_RD_BYTES];
    static EXT_RAM_BSS_ATTR uint16_t s_old_arr[N_POST];
    bool nvs_ok = false;
    int32_t rev = 1;
    memset(g_post_rd, 0, sizeof(g_post_rd));
    memset(g_post_got, 0, sizeof(g_post_got));
    memset(s_post_arr, 0, sizeof(s_post_arr));
    memset(s_post_cls, 0, sizeof(s_post_cls));         /* ★2026-11-10：缺档 = 全 0 = 普快 */
    s_api_arr = 0;
    nvs_handle_t h;
    int32_t md = 0;                                    /* 最后一次远行寄信日（日序），迁移回填用 */
    if (nvs_open("petns", NVS_READONLY, &h) == ESP_OK) {
        nvs_ok = true;
        size_t len = sizeof(g_post_rd);
        if (nvs_get_blob(h, "post_rd", g_post_rd, &len) != ESP_OK || len != sizeof(g_post_rd))
            memset(g_post_rd, 0, sizeof(g_post_rd));   /* ★2026-10-25：旧布局 blob（长度不符）= 下标已错位 → 清零 */
        /* ★B3 收到位图（2026-10-16）：**寄到才进列表**。
           ★★2026-10-18 用户令：基础明信片（g_posts 前 N_POST_BASE 张，原本注释叫「国内片」
           —— 实际并不全是国内）**不再开局全有**，走正常寄信通道（近郊寄信 / 远行按天发信）；
           老档迁移「前 47 张视为已收到」作废删除。已迁移过的旧档 NVS 现状不动。 */
        len = sizeof(g_post_got);
        if (nvs_get_blob(h, "post_got", g_post_got, &len) != ESP_OK || len != sizeof(g_post_got)) {
            memset(g_post_got, 0, sizeof(g_post_got)); /* ★2026-10-25 三.3：127→586 张扩表后旧 blob 长度
                                                           不符 = 位图按旧下标存（日常 274 张插表头 + 异国
                                                           208 追尾 ⇒ 全部错位）→ 判旧档作废，明信片从
                                                           干净状态重新收集（WiFi/好友等其余 NVS 不动）。 */
            ESP_LOGW(TAG, "★ post_got 位图缺失或为旧布局（读到 %d B / 需 %d B）→ 清零重收", (int)len, (int)sizeof(g_post_got));
        }
        /* ★2026-10-22 到达日记录（与 rd/got 同 namespace；老档无此 blob = 全 0 → 迁移） */
        len = sizeof(s_post_arr);
        if (nvs_get_blob(h, "post_arr", s_post_arr, &len) != ESP_OK || len != sizeof(s_post_arr))
            memset(s_post_arr, 0, sizeof(s_post_arr));
        /* ★A12：API 专用槽到达日（老档没有这个键 → 0，详情页回退片内 date） */
        len = sizeof(s_api_arr);
        if (nvs_get_blob(h, "api_arr", &s_api_arr, &len) != ESP_OK || len != sizeof(s_api_arr))
            s_api_arr = 0;
        /* ★2026-11-10 邮政等级（老档无此 blob → 全 0 普快，行为与升级前完全一致）*/
        len = sizeof(s_post_cls);
        if (nvs_get_blob(h, "post_cls", s_post_cls, &len) != ESP_OK || len != sizeof(s_post_cls))
            memset(s_post_cls, 0, sizeof(s_post_cls));
        nvs_get_i32(h, "exp_mail_day", &md);
        nvs_get_i32(h, "post_rev", &rev);       /* 缺失（老档）= 0 → 走 rev2 迁移 */
        nvs_close(h);
    }
    /* ★R74 一次性置换迁移：只在能打开 NVS 时做（打不开时数组是空的，写回会误清进度）。 */
    if (nvs_ok && rev < 2) {
        memcpy(s_old_rd,  g_post_rd, sizeof(g_post_rd));
        memcpy(s_old_got, g_post_got, sizeof(g_post_got));
        memcpy(s_old_arr, s_post_arr, sizeof(s_post_arr));
        memset(g_post_rd, 0, sizeof(g_post_rd));
        memset(g_post_got, 0, sizeof(g_post_got));
        memset(s_post_arr, 0, sizeof(s_post_arr));
        int ng = 0;
        for (int o = 0; o < N_POST; ++o) {
            const int n = post_rev2_map(o);
            if ((s_old_rd[o >> 3]  >> (o & 7)) & 1u) g_post_rd[n >> 3]  |= (uint8_t)(1u << (n & 7));
            if ((s_old_got[o >> 3] >> (o & 7)) & 1u) { g_post_got[n >> 3] |= (uint8_t)(1u << (n & 7)); ng++; }
            s_post_arr[n] = s_old_arr[o];
        }
        post_save();
        nvs_handle_t hr;
        if (nvs_open("petns", NVS_READWRITE, &hr) == ESP_OK) {
            nvs_set_i32(hr, "post_rev", 2);
            nvs_commit(hr);
            nvs_close(hr);
        }
        ESP_LOGW(TAG, "★ post 布局迁移 v2：4 张远行片移到表尾，%d 张收到位已按新下标重排（进度保留）", ng);
    }
    /* ★2026-10-22 迁移：老档已收到的**远行卡**（47..126）没有到达日记录 → 用最后一次
       寄信日回填（同一 blob 之后随 post_save 落盘）。常规卡（0..46）烤死日期本来就是
       合理日期，不动。 */
    if (md > 0) {
        int n_fill = 0;
        for (int i = N_POST_BASE; i < N_POST; ++i)
            if (post_is_got(i) && s_post_arr[i] == 0) { s_post_arr[i] = (uint16_t)md; n_fill++; }
        if (n_fill > 0)
            ESP_LOGI(TAG, "★ 到达日迁移：%d 张远行卡回填日序 %d", n_fill, md);
    }
    /* ★★G（2026-10-16）：API「活」明信片的内容只在 RAM（g_api_live），重启即失 ——
       开机把专用槽的 got/read 位清零，让它自动从列表/未读数里消失，
       杜绝「收到一张内容为空」的档（上次开机生成的正文不可能带过来）。 */
    g_post_got[API_POST_IDX >> 3] &= (uint8_t)~(1u << (API_POST_IDX & 7));
    g_post_rd[API_POST_IDX >> 3]  &= (uint8_t)~(1u << (API_POST_IDX & 7));
    post_order_invalidate();                       /* ★R184：开机清 API 槽后顺序要重算 */
    /* ★R113：把「积压未读 → 寄信保留率」挂在开机这一行上，玩家/排障一眼可见：
       未读 0~1 封 = 100%（不影响）；≥10 封 = 6%（几乎不再寄新片，催你看信）。 */
    /* ★2026-11-10：开机先把「在途慢递」里到期的投出来（离线几天也补得上；幂等）。
       now_local 此刻可能还没 NTP 对齐，但 RTC 日期已够判「到期」—— 投早了也只是早一天。 */
    post_slow_tick(exp_day_of(g_app.st.now_local));
    ESP_LOGI(TAG, "明信片：%d 张 · 已收到 %d · 未读 %d · 慢递在途 %d · 再寄新片保留 %d%%",
             N_POST, post_got_cnt(), post_unread(), post_slow_pending(), mail_backlog_keep_pct());
}

void post_save(void)
{
    nvs_handle_t h;
    if (nvs_open("petns", NVS_READWRITE, &h) == ESP_OK) {
        nvs_set_blob(h, "post_rd", g_post_rd, sizeof(g_post_rd));
        nvs_set_blob(h, "post_got", g_post_got, sizeof(g_post_got));
        nvs_set_blob(h, "post_arr", s_post_arr, sizeof(s_post_arr));   /* ★2026-10-22 到达日 */
        nvs_set_blob(h, "api_arr",  &s_api_arr,  sizeof(s_api_arr));   /* ★A12 API 槽到达日 */
        nvs_set_blob(h, "post_cls", s_post_cls, sizeof(s_post_cls));   /* ★2026-11-10 邮政等级 */
        nvs_commit(h);
        nvs_close(h);
    }
}

bool post_is_read(int i)
{
    /* ★G：边界从 `i < N_POST` 放宽到 `i <= API_POST_IDX` —— 专用槽 127 是合法下标 */
    return i >= 0 && i <= API_POST_IDX && ((g_post_rd[i >> 3] >> (i & 7)) & 1u);
}

bool post_is_got(int i)
{
    return i >= 0 && i <= API_POST_IDX && ((g_post_got[i >> 3] >> (i & 7)) & 1u);
}

void post_set_got(int i)
{
    if (i < 0 || i > API_POST_IDX || post_is_got(i)) return;
    g_post_got[i >> 3] |= (uint8_t)(1u << (i & 7));
    post_order_invalidate();                       /* ★R184：显示序缓存置脏 */
    g_post_unread = post_unread();                 /* 到达即挂未读 → 主页角标（幂等重算） */
}

void post_mark_read(int i)
{
    if (i < 0 || i > API_POST_IDX || post_is_read(i)) return;
    g_post_rd[i >> 3] |= (uint8_t)(1u << (i & 7));
    post_order_invalidate();                       /* ★R184：同一天里未读优先，已读会动顺序 */
    post_save();
    ESP_LOGI(TAG, "明信片「%s」标为已读（未读剩 %d）", post_at(i)->title, post_unread());
}

void post_mark_unread(int i)
{
    if (i < 0 || i > API_POST_IDX || !post_is_read(i)) return;
    g_post_rd[i >> 3] &= (uint8_t)~(1u << (i & 7));
    post_order_invalidate();                       /* ★R184 */
    g_post_unread = post_unread();
}

int post_unread(void)
{
    int n = 0;
    for (int i = 0; i <= API_POST_IDX; ++i)
        if (post_is_got(i) && !post_is_read(i)) n++;   /* ★B3：没寄到的谈不上未读 */
    return n;
}

/* ★B3（2026-10-16）：已收到张数 —— 列表/详情页的总数、页码分母都用它（不是 N_POST）。 */
/* ★R157：还有多少张预制明信片没收到 —— 归零时日常寄信 100% 走 AI 片。
   只数基础池 N_POST_BASE，与 post_pick_base() 的取片范围同源。 */
int post_ungot_count(void)
{
    int n = 0;
    for (int i = 0; i < N_POST_BASE; ++i) if (!post_is_got(i)) ++n;
    return n;
}

int post_got_cnt(void)
{
    int n = 0;
    for (int i = 0; i <= API_POST_IDX; ++i)
        if (post_is_got(i) && (g_post_cat < 0 || post_cat_of(i) == g_post_cat)) n++;
    return n;
}

/* ★★2026-10-26 修 bug②③：**近郊寄信按去向抽片**。
   原实现是 `esp_random() % N_POST_BASE` 在近郊池里纯随机 —— 可效果表里
   LFX_MAIL_PP + LFX_SC_WILD / _SEA / _CITY 三行是**按去向**加寄信概率的，
   于是出现「概率按去向算了，抽到的片却不按去向选」：去山野时概率提高了，
   寄回来的可能是一张都市片或海滨城市的片 —— 文案与体验都对不上。

   现在的做法：每张片在 POST_SER_MASK[] 里有一个「适用去向」bitmask（位顺序与
   LOOT_SER_CITY/WILD/SEA 一一对应），抽片时**先按本次 dest 过滤候选池**：
     · 第 1 轮只收「专属」该去向的片（mask == want）—— 保证抽到的确实是那个场景；
     · 第 1 轮池空才放宽到含通配（笔友邮局 / 中性地点，mask & want）—— 保底不空手。
   未知去向（远行走这条路 / dest 越界）返回 -1，由调用方回退到旧的纯随机。

   ⚠ 归类表是**初稿口径，待用户确认**（见 _REFACTOR_STATUS.md）：现在沿海大都会
   算「城市」、滩涂海岛算「海滨」、山林湖原算「山野」。口径一改 → 重跑
   scripts/_tools/gen_post_ser_mask.py 再重编即可，不用动这里的逻辑。 */
_Static_assert(sizeof(POST_SER_MASK) == N_POST,
              "post_ser_mask.h 与 g_posts[] 不同步 —— 请重跑 scripts/_tools/gen_post_ser_mask.py");

static bool post_is_far_city(const char *c)
{
    /* ★2026-10-26 修（近郊池混入远行片）：g_posts[] 表头旧 298 张里有 4 张的 city 是
       京都(3)/威尼斯(1) —— 它们是远行十站池的片，却因为扩表时排在 [0,298) 里。
       ★R74 已把 4 张挪到表尾（[0,294) 不再有远行片）；本函数保留为**防御性过滤**：
       以后若再扩表把远行片插错位置，抽片仍不会串味。 */
    static const char *const FAR[EXP_N] = { "冰岛", "京都", "撒哈拉", "威尼斯", "土耳其",
                                            "秘鲁", "埃及", "摩洛哥", "新西兰", "印度" };
    for (int i = 0; i < EXP_N; ++i)
        if (c && !strcmp(c, FAR[i])) return true;
    return false;
}

static int post_pick_masked(uint8_t want, bool exact)
{
    int chosen = -1, cnt = 0;
    for (int i = 0; i < N_POST_BASE; ++i) {
        if (post_is_far_city(g_posts[i].city)) continue;   /* ★远行片不进近郊池 */
        const uint8_t m = POST_SER_MASK[i];
        const bool ok = exact ? (m == want) : ((m & want) != 0u);
        if (!ok) continue;
        ++cnt;
        /* 蓄水池抽样：一趟 O(n) 扫完且每张等概率，不用在栈上开 298 项候选数组 */
        if ((int)(esp_random() % (unsigned)cnt) == 0) chosen = i;
    }
    return chosen;
}

int post_pick_base(int dest)
{
    if (dest < LOOT_SER_CITY || dest > LOOT_SER_SEA) return -1;   /* 仅近郊三去向参与过滤 */
    const uint8_t want = (uint8_t)(POST_SER_M_CITY << dest);
    int r = post_pick_masked(want, true);
    if (r < 0) r = post_pick_masked(want, false);
    return r;
}

/* ★R75：一趟出门只寄同一座城的片（用户：不要一次收到全国各地）。
   先只抽「未收到」的；同一城全收过了才允许重复。 */
int post_pick_same_city(const char *city)
{
    if (!city || !city[0]) return -1;
    int chosen = -1;
    for (int pass = 0; pass < 2 && chosen < 0; ++pass) {
        int cnt = 0;
        for (int i = 0; i < N_POST_BASE; ++i) {
            if (strcmp(g_posts[i].city, city) != 0) continue;
            if (pass == 0 && post_is_got(i)) continue;
            ++cnt;
            if ((int)(esp_random() % (unsigned)cnt) == 0) chosen = i;
        }
    }
    return chosen;
}

const char *post_dest_name(int dest)
{
    switch (dest) {
    case LOOT_SER_CITY: return "城市";
    case LOOT_SER_WILD: return "山野";
    case LOOT_SER_SEA:  return "海滨";
    case LOOT_SER_ABROAD: return "异国";
    default: return "?";
    }
}

/* ★R173 用户令（2026-11-10）：「明信片的排列顺序应该是时间越新的在上面，
   时间越久的在下面」。原来 post_order 是「未读置顶 + 其余按 g_posts[] 索引」，
   收到顺序与索引毫无关系 ⇒ 看起来乱。改成按**到达日 s_post_arr 降序**；
   同一天到的再按「未读优先」，最后按索引升序保持稳定（点开不会跳位）。
   ⚠ s_post_arr 是「第几天」的日序，不是 Unix 时间戳；越大 = 越新。
   ⚠ 老卡 arr=0（无记录）自然落在最后，符合「越久越下面」。 */
static int post_arr_day(int i)
{
    if (i == API_POST_IDX) return (int)s_api_arr;      /* API 活卡单独存到达日 */
    if (i >= 0 && i < N_POST) return (int)s_post_arr[i];
    return 0;
}

static int post_cmp_newest_first(const void *pa, const void *pb)
{
    const int a = *(const int *)pa, b = *(const int *)pb;
    const int da = post_arr_day(a), db = post_arr_day(b);
    if (da != db) return (da > db) ? -1 : 1;           /* 新的排前面 */
    const int ua = post_is_read(a) ? 0 : 1, ub = post_is_read(b) ? 0 : 1;
    if (ua != ub) return (ua > ub) ? -1 : 1;           /* 同日未读优先 */
    return (a < b) ? -1 : (a > b) ? 1 : 0;            /* 稳定口径 */
}

/* ★R184（性能）：显示序**缓存**。
   旧实现：post_order(k) 每次调用都把全表（最多 586 条）重建 + qsort 一遍；
   而 post_disp_of() 为了找一张卡的位置，会对 k=0..cnt-1 **逐次调用** post_order ⇒
   画一页 4 行列表最坏要做 4×586 ≈ 2300 次全量排序（约千万次比较），纯浪费。
   现在：全表只排一次，缓存在 s_ord[]；任何会改变「顺序/未读/分类/到达日」的状态改动
   都调 post_order_invalidate() 置脏。渲染路径只读缓存 ⇒ O(1)。
   ⚠ 以后新增「改 g_post_got / g_post_rd / g_post_cat / 到达日」的代码，
     必须同时调 post_order_invalidate()，否则列表顺序会滞后一帧。 */
static EXT_RAM_BSS_ATTR int s_ord[N_POST + 1];
static int s_ord_n = -1;                         /* -1 = 需重建 */

static void post_order_invalidate(void)
{
    s_ord_n = -1;
}

static void post_ord_build(void)
{
    int n = 0;
    if (post_is_got(API_POST_IDX) &&
        (g_post_cat < 0 || post_cat_of(API_POST_IDX) == g_post_cat)) s_ord[n++] = API_POST_IDX;
    for (int i = 0; i < N_POST; ++i)
        if (post_is_got(i) && (g_post_cat < 0 || post_cat_of(i) == g_post_cat)) s_ord[n++] = i;
    if (n > 1) qsort(s_ord, (size_t)n, sizeof(s_ord[0]), post_cmp_newest_first);
    s_ord_n = n;
}

int post_order(int k)
{
    if (s_ord_n < 0) post_ord_build();
    if (k < 0 || k >= s_ord_n) return -1;
    return s_ord[k];
}

int post_disp_of(int raw)
{
    if (s_ord_n < 0) post_ord_build();           /* 命中缓存时不再排序 */
    for (int k = 0; k < s_ord_n; ++k)
        if (s_ord[k] == raw) return k;
    return -1;
}

const char *post_date_disp(int i, char *buf, int cap)
{
    if (i == API_POST_IDX && s_api_arr > 0) {          /* ★A12：API 槽单独存的到达日 */
        map_date_str(s_api_arr, buf, cap);
        return buf;
    }
    if (i >= 0 && i < N_POST && s_post_arr[i] > 0) {
        map_date_str(s_post_arr[i], buf, cap);
        return buf;
    }
    const post_t *pt = post_at(i);
    return (pt && pt->date) ? pt->date : "";
}

int post_sender_kind(int i)
{
    /* ★G：边界放行 API 槽（其 city = 目的地名 → 猫猫寄的，走默认分支） */
    if (i < 0 || (i >= N_POST && i != API_POST_IDX)) return POST_SENDER_CAT;
    const char *c = post_at(i)->city;
    if (!c) return POST_SENDER_CAT;
    if (strstr(c, "小鸟")) return POST_SENDER_BIRD;
    if (strstr(c, "蝴蝶")) return POST_SENDER_BUTTERFLY;
    return POST_SENDER_CAT;
}

const char *post_sender(int i)
{
    if (i < 0 || (i >= N_POST && i != API_POST_IDX)) return "";
    switch (post_sender_kind(i)) {
    case POST_SENDER_BIRD:      return "小鸟";
    case POST_SENDER_BUTTERFLY: return "蝴蝶";
    default:                    return g_pet_name;
    }
}

/* ★★ 2026-11-10 用户令（实机报「正面紫藤架 上海 春，背面却是嘉定，对不上」）：
   背面左上那格（邮编框正下方 TP_CT_XY）的语义 = **寄件来源/邮局**，不是城市。
   证据：照片信同一格画的是 mypost_source_name()（「手机相册」，注释原话
   「内置明信片这里显示小鸟/蝴蝶邮局」）；而这格此前对内置片直接画 city 字段，
   于是猫猫寄的 486 条退化成真实城市名（如「嘉定」），100 条笔友信才是「小鸟/蝴蝶邮局」。
   三式与 post_sender_kind 同源 ⇒ 与列表行尾寄信人、背面邮票图案永远一致。
   ⚠ city 字段本身**不改**（分类 post_cat_of 与明信片「近郊/同城」抽取都靠它）。
   返回中文原文，上屏由调用方 t_()（与原来是 t_(p->city) 同款）。 */
const char *post_sender_post_name(int i)
{
    switch (post_sender_kind(i)) {
    case POST_SENDER_BIRD:      return "小鸟邮局";
    case POST_SENDER_BUTTERFLY: return "蝴蝶邮局";
    default:                    return "猫猫邮局";
    }
}

/* ★★ 2026-10-18 明信片分类判据：常规信件（默认/API 槽）· 笔友来信（小鸟/蝴蝶邮局）。 */
static int post_cat_of(int i)
{
    const int k = post_sender_kind(i);
    return (k == POST_SENDER_BIRD || k == POST_SENDER_BUTTERFLY) ? 1 : 0;
}

/* ★R218：抽一张**未收到**的笔友来信（小鸟/蝴蝶邮局）。
   背景：笔友信在 POST_SER_MASK 里是 0x07 通配，post_pick_base() 第一轮 exact
   只认 m==want(1/2/4)，第二轮仅在专属片全空时才放宽 ⇒ 笔友信命中率恒 0，
   用户从来收不到。这里给笔友信一条**独立通道**，不塞进普通近郊池
   （否则 92 张笔友信会挤掉"出门寄同城片"的体验）。
   返回下标或 -1（全收过）。用蓄水池抽样在笔友片里等概率挑。 */
int post_pick_penpal(void)
{
    int chosen = -1, cnt = 0;
    for (int i = 0; i < N_POST_BASE; ++i) {
        if (post_cat_of(i) != 1) continue;
        if (post_is_got(i)) continue;             /* 优先没收到过的 */
        ++cnt;
        if ((int)(esp_random() % (unsigned)cnt) == 0) chosen = i;
    }
    if (chosen >= 0) return chosen;
    /* 全收过 → 允许重复（笔友信是有温度的内容，重复也不算坏体验） */
    for (int i = 0; i < N_POST_BASE; ++i) {
        if (post_cat_of(i) != 1) continue;
        ++cnt;
        if ((int)(esp_random() % (unsigned)cnt) == 0) chosen = i;
    }
    return chosen;
}

int post_cat_cnt(int c)
{
    int n = 0;
    for (int i = 0; i <= API_POST_IDX; ++i) if (post_is_got(i) && post_cat_of(i) == c) n++;
    return n;
}

int post_cat_unread(int c)
{
    /* ★2026-10-23：分类 2 =「特殊信件」（动态信箱 mypost），它不在内置明信片位图里，
       未读要单独问 mypost_unread()，否则网页上传的新卡永远没有红点。 */
    if (c == 2) return mypost_unread();
    int n = 0;
    for (int i = 0; i <= API_POST_IDX; ++i)
        if (post_is_got(i) && !post_is_read(i) && post_cat_of(i) == c) n++;
    return n;
}

void post_cat_pick(int c)
{
    if (c == MYPOST_CAT) { mypost_enter(); return; }
    if (c == FAV_CAT)    { fav_enter();    return; }
    g_post_cat = c;
    post_order_invalidate();                       /* ★R184：换分类 = 换过滤集合 */
    go_page(PG_POST_LIST);
}

int post_back_screens(const char *note)
{
    return (fb_text_note_lines(ZF_FONT_TITLE, note) > POST_NOTE_LINES) ? 2 : 1;
}

void post_flip(void)
{
    const int i = post_view_i();    /* ★G：API 槽不经 N_POST 取模（会卷回 0） */
    const int back_n = (i >= 0 && i <= API_POST_IDX) ? post_back_screens(post_at(i)->note) : 1;
    if (g_post_side == 0)        g_post_side = 1;              /* 正面 → 背面第 1 屏 */
    else if (g_post_side < back_n) g_post_side += 1;           /* 背面 1 → 背面 2 */
    else                          g_post_side = 0;             /* 末屏 → 正面 */
    ESP_LOGI(TAG, "明信片翻面 → %s（该张背面 %d 屏）",
             (g_post_side == 0) ? "正面（照片）"
                                : (g_post_side == 1 ? "背面第1屏" : "背面第2屏"),
             back_n);
}

void post_flip_back(void)
{
    const int i = post_view_i();    /* ★G：API 槽不经 N_POST 取模（会卷回 0） */
    const int back_n = (i >= 0 && i <= API_POST_IDX) ? post_back_screens(post_at(i)->note) : 1;
    g_post_side = (g_post_side == 0) ? back_n : g_post_side - 1;
    ESP_LOGI(TAG, "明信片反向翻面 → %s（该张背面 %d 屏）",
             (g_post_side == 0) ? "正面（照片）"
                                : (g_post_side == 1 ? "背面第1屏" : "背面第2屏"),
             back_n);
}

/* 条目时间戳（统一编码：内置槽 k≥0 查 s_mp_ts；卡信 e<0 查 s_sd[]）。 */
uint32_t mypost_entry_ts(int e)
{
    if (e >= 0) return (e < MYPOST_MAX) ? s_mp_ts[e] : 0;
    int i = -2 - e;
    return (i >= 0 && i < s_sd_n) ? s_sd[i] : 0;
}

static bool mypost_before(int a, int b)
{
    const uint32_t ta = mypost_entry_ts(a), tb = mypost_entry_ts(b);
    if (ta != tb) return ta > tb;
    const int pa = (a >= 0) ? a : (MYPOST_MAX + (-2 - a));
    const int pb = (b >= 0) ? b : (MYPOST_MAX + (-2 - b));
    return pa < pb;
}

/* ★R147 修 P1：卡信编码原本是 e = -1-i，与「-1 = 这一位次不存在」的返回值撞车 ——
   只要卡上有转存信，best 变负就被下面 `if (best < 0) return -1` 判成「找不到」，
   于是「特殊信件」列表首行就 break（整页空白）、详情页画空态、删除变空操作。
   现在卡信编码改到 **e = -2-i**（-1 只表示不存在），best 的 -1 哨兵恢复单义。 */
int mypost_rank_entry(int rank)
{
    if (rank < 0) return -1;
    int  last = -1;
    bool have = false;
    for (int it = 0; it <= rank; ++it) {
        int best = -1;
        for (int k = 0; k < MYPOST_MAX; ++k) {
            if (!s_mp_ts[k]) continue;
            if (have && !mypost_before(last, k)) continue;
            if (best < 0 || mypost_before(k, best)) best = k;
        }
        for (int i = 0; i < s_sd_n; ++i) {
            if (!s_sd[i]) continue;
            const int e = -2 - i;
            if (have && !mypost_before(last, e)) continue;
            if (best < 0 || mypost_before(e, best)) best = e;
        }
        if (best < 0) return -1;
        last = best;
        have = true;
    }
    return last;
}

/* 条目在显示序中的位次（0-based）；条目不存在 = -1。 */
int mypost_entry_rank(int e)
{
    if (e >= 0) { if (e >= MYPOST_MAX || !s_mp_ts[e]) return -1; }
    else        { const int i = -2 - e; if (i < 0 || i >= s_sd_n || !s_sd[i]) return -1; }
    int r = 0;
    for (int k = 0; k < MYPOST_MAX; ++k)
        if (s_mp_ts[k] && mypost_before(k, e)) ++r;
    for (int i = 0; i < s_sd_n; ++i)
        if (s_sd[i] && mypost_before(-2 - i, e)) ++r;
    return r;
}

/* 按 ts 反查条目（同 ts 取显示序最靠前的一条）；不存在 = -1。 */
int mypost_entry_by_ts(uint32_t ts)
{
    if (!ts) return -1;
    int best = -1;
    for (int k = 0; k < MYPOST_MAX; ++k)
        if (s_mp_ts[k] == ts && (best < 0 || mypost_before(k, best))) best = k;
    for (int i = 0; i < s_sd_n; ++i)
        if (s_sd[i] == ts && (best < 0 || mypost_before(-2 - i, best))) best = -2 - i;
    return best;
}

bool mypost_read_row(int e, int y, uint8_t *dst)
{
    if (!s_mp_ready || !dst || y < 0 || y >= POST_H) return false;
    if (e >= 0) {
        if (e >= MYPOST_MAX || !s_mp_ts[e]) return false;
        return assets_read(s_mp_off + MYPOST_SLOT_OFF + (uint32_t)e * MYPOST_SLOT_SZ
                           + (uint32_t)y * POST_ROW, dst, POST_ROW);
    }
    /* 卡信：按需开流逐行读（不缓存整帧）*/
    return mypost_sd_read(-2 - e, (uint32_t)y * POST_ROW, POST_ROW, dst);
}

/* 卡片数 + 光标/偏移夹具（卡片被删或数量变化后别停在空页 / 越界行） */
void mypost_cnt_refresh(void)
{
    /* ★2026-10-22 Stage D：清单总数 = 内置槽 + TF卡溢出信（卡信是「额外的」，不计入
       X/200 分母——X 口径只数内置 200 动态槽，见分类页）。 */
    s_myp_cnt = mypost_count() + s_sd_n;
    if (s_myp_cnt < 0) s_myp_cnt = 0;
    if (s_myp_sel > s_myp_cnt) s_myp_sel = s_myp_cnt;
    /* ★2026-10-22 B：制作行删除 → 光标域 = 1..cnt（0 只在空库时出现） */
    if (s_myp_sel < 1 && s_myp_cnt > 0) s_myp_sel = 1;
    if (s_myp_sel < 0) s_myp_sel = 0;
    /* 卡片区翻页：光标在卡片上 → 页 = 该卡所在页；在制作行 → 回第 1 页 */
    s_myp_off = (s_myp_sel >= 1) ? (((s_myp_sel - 1) / MYP_LIST_NVIS) * MYP_LIST_NVIS) : 0;
}

bool mypost_text_page(int x, int y0, const char *s, int start_line)
{
    /* ★2026-10-22 用户令：背面文字改成 **12px**（与常规明信片背面一致）——
       直接复用明信片的 12px 分页绘制（折行/行距 22/每屏 4 行同源，翻页对齐）。 */
    return fb_text_note_page(ZF_FONT_TITLE, x, y0, s, start_line);
}

/* 背面总屏数（0 = 无文字 → 单面，不可翻面）。与 12px 渲染同源：按前进宽度折行计数。 */
int mypost_text_screens(const char *s)
{
    if (!s || !*s) return 0;
    return (fb_text_note_lines(ZF_FONT_TITLE, s) + POST_NOTE_LINES - 1) / POST_NOTE_LINES;
}

const char *mypost_source_name(int e)
{
    /* ★R189：按槽 meta[8] 的来源位显示 —— AI 生图卡原来一律写「手机相册」，
       用户报「新建的也是手机相册，这个不该是手机相册」。0=网页上传（真·手机相册）。 */
    if (e >= 0 && mypost_read_src(e) == 1) return T("AI生成");
    /* TODO(朋友转寄)：src=2 时返回「朋友转寄」（sender 已单存，可显示好友名） */
    /* ★2026-10-28 R104：这行上屏位置 = 明信片背面左上城市行（TP_CT_XY），
       与 g_posts 的 city 同一格 —— 原来硬编码中文，英/日态会露出「手机相册」。 */
    return T("手机相册");
}

/* ★R189：来源位（meta[8]，0=手机相册 / 1=AI生成 / 2=朋友转寄）。
   meta 是 16B（原只用前 8B），补 1 字节**向后兼容**：老卡该字节为 0 = 手机相册。
   （变量本体定义在文件顶部，mypost_add_body 之前。） */
void mypost_src_hint(uint8_t src) { s_mp_src_hint = src; }

int mypost_read_src(int k)
{
    if (k < 0 || k >= MYPOST_MAX || !s_mp_ts[k]) return 0;
    uint8_t meta[16];
    if (!assets_read(s_mp_off + MYPOST_SLOT_OFF + (uint32_t)k * MYPOST_SLOT_SZ + MYPOST_META_OFF,
                     meta, sizeof(meta))) return 0;
    return meta[8];
}

void mypost_meta_line(int k, int tlen, bool is_front)
{
    (void)tlen; (void)is_front;             /* 底部只画「地址/未知地点 + 日期」，不再用翻面提示 */
    char ab[MYPOST_ADDR_MAX + 1];
    const int aal = mypost_read_addr(k, ab, sizeof(ab));
    const uint32_t mts = (k >= 0) ? s_mp_ts[k] : s_sd[-2 - k];
    const bool has_date = (mts >= 1704067200u);
    char db[8];
    if (has_date) map_date_str((int)(mts / 86400u), db, (int)sizeof(db));
    if (aal > 0) {
        fb_text_l_fit(ZF_FONT_BODY, POST_PLACE_X, 161, ab, POST_PLACE_W);
    } else {                                /* ★2026-10-22 用户令：地址（地点）选填，未填 → 显示「未知地点」*/
        fb_text_l(ZF_FONT_BODY, POST_PLACE_X, 161, T("未知地点"));
    }
    if (has_date) fb_text_r(ZF_FONT_BODY, POST_DATE_X, 161, db);
}

void mypost_inv_inside(int x0, int y0, int x1, int y1)
{
    for (int y = y0 + 1; y <= y1 - 1; ++y)
        for (int x = x0 + 1; x <= x1 - 1; ++x)
            fb[y][x] = (uint8_t)(255 - fb[y][x]);
}

/* ★2026-10-26 用户实机报「转发失败」：MQTT 发送要求 WiFi 已连上，而深睡/复位后可能掉线。
   发送前先确保联网（已连则立即返回），失败返回 -5 → 结果页显示「无网络」。 */
static int fwd_ensure_net(void)
{
    if (g_app.cfg && ws_wifi_connect(g_app.cfg, 15000)) return 0;
    ESP_LOGW(TAG, "★ 转发：WiFi 未连上 → 发送取消（先联网再试）");
    return -5;
}

/* 把 friend_net_send_post 的返回码映射成结果页文案（失败原因可见，不再只有「转发失败」）。 */
static void fwd_show_rc(int rc, page_t back, const char *tag)
{
    const char *why = NULL;
    if (rc == -5)      why = T("无网络");
    else if (rc == -2) why = T("连不上服务器");
    else if (rc == -3 || rc == -4) why = T("发送失败");
    ESP_LOGW(TAG, "★ 转发%s：%s（rc=%d）", tag, rc == 0 ? "成功" : "失败", rc);
    fwd_result_show_ex(rc == 0, back, why);
}

void mypost_fwd_send(void)
{
    if (g_fwd_sending) return;
    if (g_fwd_sel < 0 || g_fwd_sel >= friend_count()) return;
    /* ★预制明信片分支（规格 _fwd_post.py）：图 = post 槽，文字 = 背面话/地点 */
    if (g_fwd_is_post) {
        const int pi = g_fwd_post_idx;
        if (pi < 0 || pi >= N_POST) return;
        static EXT_RAM_BSS_ATTR uint8_t photo[POST_BYTES];
        if (!assets_post_photo(g_posts[pi].photo, photo)) {
            ESP_LOGW(TAG, "★ 转发：读预制卡照片槽 %d 失败", g_posts[pi].photo);
            fwd_result_show_ex(false, PG_POST_ITEM, T("读取卡片失败"));
            return;
        }
        /* ★R173 用户令：转发来的内置预制片也要带猫精灵。
           本机信箱里猫是「显示时临时叠」的（post_sprite_pick/draw），转发传的是
           原始位图 ⇒ 收件侧原本光秃秃一张风景。这里在发送前把猫画进位图。 */
        const int cat_i = post_sprite_pick((uint32_t)g_posts[pi].photo);
        if (cat_i >= 0) post_sprite_draw(photo, cat_i);
        /* post.bin 的 1-bit 是 1=墨；mypost 槽 / 转发协议是 1=白。
           收件侧 friend_post_recv_cb 原样落槽，所以发送前必须逐字节取反，
           否则收件侧整张黑白颠倒（与 api_image.c 落箱前的 ~photo 同口径）。 */
        for (int i = 0; i < POST_BYTES; ++i) photo[i] = (uint8_t)~photo[i];
        static EXT_RAM_BSS_ATTR uint8_t rest[256];
        char text[MYPOST_TEXT_MAX + 1] = {0}, title[MYPOST_TITLE_MAX + 1] = {0};
        strlcpy(text,  g_posts[pi].note,  sizeof(text));
        strlcpy(title, g_posts[pi].place, sizeof(title));
        int tl = (int)strlen(text);  if (tl > (int)MYPOST_TEXT_MAX)  tl = (int)MYPOST_TEXT_MAX;
        int tal = (int)strlen(title); if (tal > (int)MYPOST_TITLE_MAX) tal = (int)MYPOST_TITLE_MAX;
        int rl = 0;
        rest[rl++] = (uint8_t)tl;  memcpy(rest + rl, text,  (size_t)tl);  rl += tl;
        rest[rl++] = (uint8_t)tal; memcpy(rest + rl, title, (size_t)tal); rl += tal;
        rest[rl++] = 0;
        friend_net_set_self_name(g_pet_name);       /* ★v3：转发时也把猫名带上 */
        friend_net_set_self((int)g_rtc_mood_lvl, g_app.st.intimacy,
                            (int)(g_app.st.now_local / 86400),
                            app_self_vis(), g_app.st.now_local);
        g_fwd_sending = true;
        page_render(true);
        int rc = fwd_ensure_net();
        if (rc == 0) rc = friend_net_send_post(g_fwd_sel, photo, rest, rl);
        g_fwd_sending = false;
        g_fwd_post_idx = -1; g_fwd_is_post = false;
        fwd_show_rc(rc, PG_POST_ITEM, "预制卡");   /* ★2026-10-26：失败页带原因 */
        return;
    }
    /* ★照片信件分支：图 = 槽照片，文字 = 槽背面文字（标题留给收件侧换转发者昵称） */
    static EXT_RAM_BSS_ATTR uint8_t photo[MYPOST_DATA_BYTES];
    /* ★R213（用户令）：g_fwd_slot 现在存的是**条目编码**（≥0 内置槽 / ≤-2 卡信），
       只有 -1 才是「没选中」。旧判据 `< 0` 会把卡信当失败直接拒掉。 */
    if (g_fwd_slot == -1 || !mypost_read(g_fwd_slot, photo)) {
        ESP_LOGW(TAG, "★ 转发：读照片条目 %d 失败（可能已被顶掉）", g_fwd_slot);
        fwd_result_show_ex(false, PG_MYPOST_ITEM, T("读取卡片失败"));
        return;
    }
    static EXT_RAM_BSS_ATTR uint8_t rest[256];
    char text[MYPOST_TEXT_MAX + 1] = {0}, title[MYPOST_TITLE_MAX + 1] = {0},
         addr[MYPOST_ADDR_MAX + 1] = {0};
    int tl = mypost_read_text(g_fwd_slot, text, (int)sizeof(text));
    if (tl < 0) tl = 0;
    if (tl > (int)MYPOST_TEXT_MAX) tl = (int)MYPOST_TEXT_MAX;
    /* ★R154（用户 2026-11-09 18:47 实机报）：转发曾把 tal/aal 写死 0，自己写的标题
       「超冷的一天」和地点「家里」全部丢掉 ⇒ 收件侧列表退化成「信件 N · 有字」、
       详情显示「未知地点」。R119 / 10-27 用户令已改为「标题保留卡片自己的名字，
       转发者昵称单独存字段块末尾 [sl][sender]」，发送侧必须把原卡字段原样带过去。
       三段上限 1+180+1+30+1+36 = 249 B < rest[256]，安全。 */
    int tal = mypost_read_title(g_fwd_slot, title, (int)sizeof(title));
    if (tal < 0) tal = 0;
    int aal = mypost_read_addr(g_fwd_slot, addr, (int)sizeof(addr));
    if (aal < 0) aal = 0;
    int rl = 0;
    rest[rl++] = (uint8_t)tl;   memcpy(rest + rl, text,  (size_t)tl);  rl += tl;
    rest[rl++] = (uint8_t)tal;  memcpy(rest + rl, title, (size_t)tal); rl += tal;
    rest[rl++] = (uint8_t)aal;  memcpy(rest + rl, addr,  (size_t)aal); rl += aal;
    friend_net_set_self((int)g_rtc_mood_lvl, g_app.st.intimacy,
                        (int)(g_app.st.now_local / 86400),
                        app_self_vis(), g_app.st.now_local);
    g_fwd_sending = true;
    page_render(true);
    int rc2 = fwd_ensure_net();
    if (rc2 == 0) rc2 = friend_net_send_post(g_fwd_sel, photo, rest, rl);
    g_fwd_sending = false;
    g_fwd_slot = -1;
    fwd_show_rc(rc2, PG_MYPOST_ITEM, "照片信件");   /* ★2026-10-26：失败页带原因 */
}

/* 操作页「转发」确认入口（三处共用）：解析 s_op → 进好友选择页 */
void mypost_fwd_begin(void)
{
    if (friend_count() <= 0) {                     /* ★R76：纯文字提示页 + 3s 自动回 */
        ESP_LOGW(TAG, "★ 转发：还没有好友 → 提示页");
        go_page(PG_FWD_NOFRIEND);
        return;
    }
    g_fwd_is_post  = (s_op.kind != 0);
    g_fwd_post_idx = g_fwd_is_post ? (int)s_op.key : -1;
    g_fwd_slot     = -1;
    if (!g_fwd_is_post) {
        /* ★R213（用户令）：按 ts 反查条目 —— 同时覆盖内置槽（0..199）与 TF卡信（e≤-2）。
           原来只扫 s_mp_ts[]，卡信永远找不到 ⇒ 点「转发」必提示「这张卡已失效」。 */
        g_fwd_slot = mypost_entry_by_ts(s_op.key);
        if (g_fwd_slot == -1) {
            ESP_LOGW(TAG, "★ 转发：找不到原卡（可能已被顶掉）");
            /* ★R125：不再静默 return —— 玩家点了「转发」要有明确失败反馈 */
            fwd_result_show_ex(false, s_myp_back, T("这张卡已失效"));
            return;
        }
    } else if (g_fwd_post_idx < 0 || g_fwd_post_idx >= N_POST) {
        fwd_result_show_ex(false, s_myp_back, T("这张卡暂时无法转发"));
        return;
    }
    g_fwd_sel = -1;
    g_fwd_off = 0;
    go_page(PG_MYPOST_FWD);
    page_render(false);
}

/* 翻面循环：正面 → 背面第 1 屏 →（有第 2 屏）→ 回正面。单面卡不翻（返回 false）。 */
bool mypost_flip(void)
{
    const int screens = mypost_text_screens(s_myp_txt);
    if (screens <= 0) return false;                 /* 单面：没有文字页可翻 */
    s_myp_side = (s_myp_side + 1) % (screens + 1);
    return true;
}

/* ★R155（用户 2026-11-09 19:09 实机报）：按显示位次清未读，供所有「进详情」路径共用。
   触屏列表页与收藏夹入口原本自己拼 go_page，漏了清未读 ⇒ 点开照片信件后
   特殊信件红点与首页邮件提示永不消失（按键版走 mypost_open_sel 一直正常）。
   e == -1 = 取不到条目；卡信 e<=-2 没有稳定槽号，清 mp_sd_unrd 的 0/1 全局标志。 */
void mypost_mark_read_sel(void)
{
    const int e = mypost_rank_entry(s_myp_sel - 1);
    if (e == -1) return;
    if (e >= 0) mypost_unrd_set(e, false);
    else        loot_nvs_set_i32("mp_sd_unrd", 0);
}

bool mypost_open_sel(void)
{
    if (s_myp_sel < 1) return true;                  /* 空库无选中：吞掉 */
    if (s_myp_sel > s_myp_cnt) return true;          /* 越界：吞掉（用缓存计数，避免 1920B 栈数组）*/
    mypost_mark_read_sel();                          /* ★2026-10-23：进详情即清未读 */
    s_myp_side = 0;
    s_myp_back = PG_MYPOST_LIST;                      /* 正常从列表进 → 返回回列表 */
    go_page(PG_MYPOST_ITEM);
    page_render(false);
    return true;
}

void mypost_notice_tick(void)
{
    if (!s_myp_notice || g_page == PG_MYPOST_NOTICE) return;
    s_myp_notice_show = s_myp_notice;
    s_myp_notice      = 0;
    s_myp_notice_back = g_page;
    go_page(PG_MYPOST_NOTICE);      /* go_page 内含全刷渲染 → 提示页当场出 */
    ESP_LOGI(TAG, "页：mypost 满仓提示（%s）",
             s_myp_notice_show == 3 ? "满200转存TF卡" :
             s_myp_notice_show == 2 ? "满200顶掉告知" : "将满预警");
}

void mypost_enter(void)
{
    if (!s_mp_ready) {                                /* 存储层没起来 → 只能去做新的 */
        ESP_LOGW(TAG, "我的信件：mypost 未就绪 → 直接起导入门户");
        post_enter();
        return;
    }
    mypost_sd_scan();                                /* ★2026-10-22 Stage D：建卡信清单（无卡则 s_sd_n=0）*/
    mypost_cnt_refresh();
    s_myp_sel  = (s_myp_cnt > 0) ? 1 : 0;             /* ★B：制作行删除 → 光标落第 1 张卡 */
    s_myp_off  = 0;
    s_myp_side = 0;
    go_page(PG_MYPOST_LIST);        /* ★2026-10-22：go_page 内部已 page_render(false)，
                                       原这里又跟一句 → 同页白画两遍（第二遍差分 0，旧规则还会
                                       触发一次 1.8s 整屏全刷，见 epd_commit 的 diff==0 注释）*/
}

void post_enter(void)
{
    /* ★2c：记住来源页（取消/返回时回它）—— 从列表「＋ 制作新信件」进来就回列表。 */
    if (g_page != PG_POST_IMPORT) s_post_back = g_page;
    /* ★2026-10-22 E 项：进门户时快照 now_local（菜单里主循环冻结 now_local，
       分钟级误差可接受）→ mypost_add 用它当创建时刻/列表排序键/详情页日期。 */
    mypost_clock_set((uint32_t)g_app.st.now_local);
    if (s_upg_open) { ws_upgrade_close(); s_upg_open = false; }
    if (!ws_post_open()) { ESP_LOGE(TAG, "★ 照片导入热点开启失败"); return; }
    s_post_open = true;
    go_page(PG_POST_IMPORT);
    page_render(false);
}

void post_import_cancel(void)
{
    if (s_post_open) { ws_post_close(); s_post_open = false; }
    go_page(s_post_back);                 /* ★2c：回**来源页**（功能页 / 照片信件列表） */
    s_post_back = PG_FUNC;                /* 用完复位，下次默认仍是功能页 */
    page_render(false);
}

void post_goto(int delta)
{
    /* ★R142（用户报「从我的收藏点进去，上下滑翻的却是常规信件」）：先问收藏域 ——
       从收藏进详情时，翻张只在**收藏过的明信片**之间走（顺序 = 收藏顺序，到头回绕）；
       不在收藏域 / 当前片不在收藏里 → 返回 -1，落回下面的全局已收到集合逻辑。 */
    {
        const int nf = post_fav_step(g_post_view, delta);
        if (nf >= 0) {
            g_post_view = nf;
            g_post_side = 0;                 /* 与全集域同口径：换张永远回正面 */
            post_mark_read(g_post_view);
            g_post_unread = post_unread();
            page_render(false);
            ESP_LOGI(TAG, "明信片翻张（收藏域 %s）→ 片 %d", (delta >= 0) ? "下一张" : "上一张",
                     g_post_view);
            return;
        }
        /* ★R144：在收藏域但当前片已失效（被删 / got 位重置 / API 槽开机清零）时，
           保持当前页不翻，绝不落到下面的全局已收到集合 —— 否则 R142 修的
           「从收藏点进去却翻到常规信件」在边界条件下原样复现。 */
        if (post_fav_domain()) return;
    }
    const int cnt = post_got_cnt();          /* ★2026-10-18：清零（cnt=0）→ 直接不收 */
    if (cnt <= 0) return;
    int v = post_disp_of(g_post_view);       /* 当前张在「已收到显示序」里的位置 */
    if (v < 0) v = 0;                        /* 理论上进详情前必在序里；兜底落第 1 张 */
    v = (v + delta + cnt) % cnt;             /* 双取模 → 负数也回绕 */
    const int idx = post_order(v);
    if (idx < 0) return;
    g_post_view = idx;
    g_post_side = 0;
    post_mark_read(g_post_view);
    g_post_unread = post_unread();
    page_render(false);
    ESP_LOGI(TAG, "明信片翻张（%s）→ 已收到第 %d/%d 张（正面）",
             (delta >= 0) ? "下一张" : "上一张", post_disp_of(g_post_view) + 1, cnt);
}

static void post_hold_btn_invert(void)
{
    rr_invert_inside(8, 164, 191, 191, 2);      /* 视觉框 = 底图烤死的按钮（rr=2） */
    epd_commit(fb_pack(), false);
}

void post_hold_tick(int x, int y)
{
    static int64_t t0 = 0;
    static bool inverted = false;

    if (g_page != PG_POST_IMPORT) {              /* 离页（含已由本函数切走）：收尾复位 */
        if (inverted) { post_hold_btn_invert(); inverted = false; }
        t0 = 0;
        return;
    }
    if (!(x >= 0 && y >= 0) || !tz_hit(x, y, &TZ_PROV_SKIP)) {
        if (inverted) { post_hold_btn_invert(); inverted = false; }
        t0 = 0;
        return;
    }
    int64_t now = esp_timer_get_time();
    if (!t0) { t0 = now; return; }               /* 刚按下：这一拍只记起点 */
    int ms = (int)((now - t0) / 1000);
    if (!inverted && ms >= 150) { post_hold_btn_invert(); inverted = true; }
    if (ms >= POST_HOLD_MS) {
        t0 = 0;
        inverted = false;                        /* 收尾的重画交给 post_import_cancel 的 page_render */
        ESP_LOGW(TAG, "★ 照片信件页底部按钮按住 %dms → 收门户回功能页（不联网）", ms);
        fflush(stdout);
        post_import_cancel();
    }
}
